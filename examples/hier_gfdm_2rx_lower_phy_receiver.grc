options:
  parameters:
    author: Johannes Demel
    category: '[GFDM]'
    generate_options: hb
    id: hier_gfdm_2rx_lower_phy_receiver
    output_language: python
    title: GFDM 2RX lower PHY receiver
  states: {}

blocks:
- name: frame_len
  id: variable
  parameters:
    value: timeslots * subcarriers + 2 * cp_len + 2 * cs_len + 2 * subcarriers
  states: {}
- name: activate_cfo_compensation
  id: parameter
  parameters:
    label: Activate CFO compensation
    type: intx
    value: '1'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '60'
  states: {}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: float
  states: {}
- name: cp_len
  id: parameter
  parameters:
    label: CP length
    type: intx
    value: '16'
  states: {}
- name: cs_len
  id: parameter
  parameters:
    label: CS length
    type: intx
    value: '8'
  states: {}
- name: frequency_domain_taps
  id: parameter
  parameters:
    label: Frequency domain taps
    value: list(range(60))
  states: {}
- name: gfdm_constellation
  id: parameter
  parameters:
    label: Constellation object
    value: digital.constellation_calcdist([-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j], [0, 1, 3, 2],4, 1).base()
  states: {}
- name: gfdm_extract_burst_cc_0_0
  id: gfdm_extract_burst_cc
  parameters:
    burst_len: frame_len
    burst_start_tag: tag_key
    tag_backoff: cp_len
    use_cfo_compensation: activate_cfo_compensation
  states: {state: disabled}
- name: gfdm_extract_burst_cc_1
  id: gfdm_extract_burst_cc
  parameters:
    burst_len: frame_len
    burst_start_tag: tag_key
    tag_backoff: cp_len
    use_cfo_compensation: activate_cfo_compensation
  states: {state: disabled}
- name: gfdm_receiver_cc_0
  id: gfdm_receiver_cc
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    activate_phase_compensation: phase_compensate
    active_subcarriers: active_subcarriers
    channel_estimator_id: '1'
    constellation: gfdm_constellation
    cp_len: cp_len
    cs_len: cs_len
    frequency_domain_taps: frequency_domain_taps
    ic_iterations: ic_iterations
    map_resources_per_timeslot: 'True'
    overlap: overlap
    preamble: preamble
    ramp_len: ramp_len
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    sync_tag_key: tag_key
    timeslots: timeslots
  states: {}
- name: gfdm_receiver_cc_0_0
  id: gfdm_receiver_cc
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    activate_phase_compensation: phase_compensate
    active_subcarriers: active_subcarriers
    channel_estimator_id: '1'
    constellation: gfdm_constellation
    cp_len: cp_len
    cs_len: cs_len
    frequency_domain_taps: frequency_domain_taps
    ic_iterations: ic_iterations
    map_resources_per_timeslot: 'True'
    overlap: overlap
    preamble: preamble
    ramp_len: ramp_len
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    sync_tag_key: tag_key
    timeslots: timeslots
  states: {}
- name: hier_gfdm_receiver_tagged_0
  id: hier_gfdm_receiver_tagged
  parameters:
    active_subcarriers: active_subcarriers
    compensate_phase: phase_compensate
    cp_len: cp_len
    cs_len: cs_len
    frame_len: frame_len
    frame_start_tag_key: tag_key
    gfdm_constellation: gfdm_constellation
    ic_iterations: ic_iterations
    overlap: overlap
    preamble: preamble
    ramp_len: ramp_len
    rx_filter_taps: frequency_domain_taps
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
    which_estimator: '1'
  states: {state: disabled}
- name: hier_gfdm_receiver_tagged_1
  id: hier_gfdm_receiver_tagged
  parameters:
    active_subcarriers: active_subcarriers
    compensate_phase: phase_compensate
    cp_len: cp_len
    cs_len: cs_len
    frame_len: frame_len
    frame_start_tag_key: tag_key
    gfdm_constellation: gfdm_constellation
    ic_iterations: ic_iterations
    overlap: overlap
    preamble: preamble
    ramp_len: ramp_len
    rx_filter_taps: frequency_domain_taps
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
    which_estimator: '1'
  states: {state: disabled}
- name: hier_multicarrier_sync_0
  id: hier_multicarrier_sync
  parameters:
    output_tag_key: tag_key
    ref_preamble: preamble
    sc_high_thr: scorr_threshold_high
    sc_low_thr: scorr_threshold_low
    xcorr_comp_freq: '1'
    xcorr_det_thr: xcorr_threshold
  states: {}
- name: hier_multicarrier_sync_1
  id: hier_multicarrier_sync
  parameters:
    output_tag_key: tag_key
    ref_preamble: preamble
    sc_high_thr: scorr_threshold_high
    sc_low_thr: scorr_threshold_low
    xcorr_comp_freq: '1'
    xcorr_det_thr: xcorr_threshold
  states: {}
- name: ic_iterations
  id: parameter
  parameters:
    label: IC iterations
    type: intx
    value: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: overlap
  id: parameter
  parameters:
    label: Overlap
    type: intx
    value: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: synced0
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: synced1
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: symbols0
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: out
    type: float
  states: {}
- name: pad_sink_0_0_0_0_0
  id: pad_sink
  parameters:
    label: LLR0
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_0_0_0_0
  id: pad_sink
  parameters:
    label: LLR1
    optional: 'True'
    type: float
  states: {}
- name: pad_sink_0_0_0_1
  id: pad_sink
  parameters:
    label: estimate0
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0_1_0
  id: pad_sink
  parameters:
    label: estimate1
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0_2
  id: pad_sink
  parameters:
    label: symbols1
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: corr0
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_1_0
  id: pad_sink
  parameters:
    label: corr1
    optional: 'True'
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: phase_compensate
  id: parameter
  parameters:
    label: Do phase compensation
    value: 'True'
  states: {}
- name: preamble
  id: parameter
  parameters:
    label: Core preamble
    value: list(range(128))
  states: {}
- name: ramp_len
  id: parameter
  parameters:
    label: Ramp length
    type: intx
    value: '8'
  states: {}
- name: scorr_threshold_high
  id: parameter
  parameters:
    label: SC Higher Threshold
    type: eng_float
    value: '.98'
  states: {}
- name: scorr_threshold_low
  id: parameter
  parameters:
    label: SC Lower Threshold
    type: eng_float
    value: '0.93'
  states: {}
- name: subcarrier_map
  id: parameter
  parameters:
    label: Subcarrier map
    value: list(range(60))
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: symbolmapping_symbol_demapper_cf_0
  id: symbolmapping_symbol_demapper_cf
  parameters:
    constellation_order: gfdm_constellation.bits_per_symbol()
    constellation_type: GRAY
    snr_tag_name: cnr
  states: {}
- name: symbolmapping_symbol_demapper_cf_1
  id: symbolmapping_symbol_demapper_cf
  parameters:
    constellation_order: gfdm_constellation.bits_per_symbol()
    constellation_type: GRAY
    snr_tag_name: cnr
  states: {}
- name: tag_key
  id: parameter
  parameters:
    label: Tag key
    type: str
    value: packet_len
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}
- name: xcorr_threshold
  id: parameter
  parameters:
    label: Xcorr detection threshold
    type: eng_float
    value: '30.'
  states: {}
- name: xfdm_sync_sync_tag_align_cc_0
  id: xfdm_sync_sync_tag_align_cc
  parameters:
    num_inputs: '2'
    tag_key: tag_key
  states: {}

connections:
- [blocks_add_xx_0, '0', pad_sink_0_0_0_0, '0']
- [gfdm_extract_burst_cc_0_0, '0', hier_gfdm_receiver_tagged_0, '0']
- [gfdm_extract_burst_cc_1, '0', hier_gfdm_receiver_tagged_1, '0']
- [gfdm_receiver_cc_0, '0', pad_sink_0_0_0, '0']
- [gfdm_receiver_cc_0, '0', symbolmapping_symbol_demapper_cf_0, '0']
- [gfdm_receiver_cc_0, '1', pad_sink_0_0_0_1, '0']
- [gfdm_receiver_cc_0, '2', pad_sink_0, '0']
- [gfdm_receiver_cc_0_0, '0', pad_sink_0_0_0_2, '0']
- [gfdm_receiver_cc_0_0, '0', symbolmapping_symbol_demapper_cf_1, '0']
- [gfdm_receiver_cc_0_0, '1', pad_sink_0_0_0_1_0, '0']
- [gfdm_receiver_cc_0_0, '2', pad_sink_0_0, '0']
- [hier_gfdm_receiver_tagged_0, '0', pad_sink_0_0_0_1, '0']
- [hier_gfdm_receiver_tagged_0, '1', pad_sink_0_0_0, '0']
- [hier_gfdm_receiver_tagged_0, '1', symbolmapping_symbol_demapper_cf_0, '0']
- [hier_gfdm_receiver_tagged_1, '0', pad_sink_0_0_0_1_0, '0']
- [hier_gfdm_receiver_tagged_1, '1', pad_sink_0_0_0_2, '0']
- [hier_gfdm_receiver_tagged_1, '1', symbolmapping_symbol_demapper_cf_1, '0']
- [hier_multicarrier_sync_0, '0', xfdm_sync_sync_tag_align_cc_0, '0']
- [hier_multicarrier_sync_0, '1', pad_sink_0_1, '0']
- [hier_multicarrier_sync_1, '0', xfdm_sync_sync_tag_align_cc_0, '1']
- [hier_multicarrier_sync_1, '1', pad_sink_0_1_0, '0']
- [pad_source_0, '0', hier_multicarrier_sync_0, '0']
- [pad_source_0_0, '0', hier_multicarrier_sync_1, '0']
- [symbolmapping_symbol_demapper_cf_0, '0', blocks_add_xx_0, '0']
- [symbolmapping_symbol_demapper_cf_0, '0', pad_sink_0_0_0_0_0, '0']
- [symbolmapping_symbol_demapper_cf_1, '0', blocks_add_xx_0, '1']
- [symbolmapping_symbol_demapper_cf_1, '0', pad_sink_0_0_0_0_0_0, '0']
- [xfdm_sync_sync_tag_align_cc_0, '0', gfdm_extract_burst_cc_0_0, '0']
- [xfdm_sync_sync_tag_align_cc_0, '0', gfdm_receiver_cc_0, '0']
- [xfdm_sync_sync_tag_align_cc_0, '1', gfdm_extract_burst_cc_1, '0']
- [xfdm_sync_sync_tag_align_cc_0, '1', gfdm_receiver_cc_0_0, '0']

metadata:
  file_format: 1
