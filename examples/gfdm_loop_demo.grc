options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: gfdm_loop_demo
    max_nouts: '2048'
    output_language: python
    realtime_scheduling: '1'
    title: GFDM loopback demo
  states: {}

blocks:
- name: activate_cfo_compensation
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: ctrl_tab@1:2,0,1,1
    label: compensate CFO
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: chan_taps
  id: variable_qtgui_entry
  parameters:
    gui_hint: 'ctrl_tab@0: 2,0,1,1'
    label: Channel taps
    type: raw
    value: '[1.+1.j, .5]'
  states: {}
- name: code_conf
  id: variable
  parameters:
    comment: All coding related values are stored here
    value: polarwrap.get_polar_configuration(gfdm_constellation.bits_per_symbol() * timeslots * active_subcarriers, polar_info_bit_size , interleaver_type='convolutional')
  states: {}
- name: conf
  id: variable
  parameters:
    comment: All modulation configuration values are available here
    value: get_gfdm_configuration(timeslots, subcarriers, active_subcarriers, overlap, cp_len=16, cs_len=8, filtertype='rrc', filteralpha=0.2, cyclic_shifts=[0, 2])
  states: {}
- name: fq_off
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl_tab@0: 0,0,1,1'
    label: F Offset
    start: '0'
    step: '0.1e-3'
    stop: '3e-3'
    value: '0e-3'
  states: {}
- name: gfdm_constellation
  id: variable_constellation
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: ic_iter_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:0,0,1,1
    label: IC Iterations
    min_len: '50'
    rangeType: int
    start: '0'
    step: '1'
    stop: '8'
    value: '2'
  states: {}
- name: noise_voltage
  id: variable_qtgui_range
  parameters:
    gui_hint: 'ctrl_tab@0: 1,0,1,1'
    label: Noise
    start: '0'
    step: '0.005'
    stop: '1'
    value: '0.01'
  states: {}
- name: phase_compensate
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: ctrl_tab@1:1,0,1,1
    label: compensate phase
    'true': '1'
    type: int
    value: '1'
  states: {}
- name: polar_info_bit_size
  id: variable
  parameters:
    value: 8 * 56
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 15.625e6
  states: {}
- name: scorr_threshold_high
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:5,0,1,1
    label: SCorr Threshold High
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.98'
  states: {}
- name: scorr_threshold_low
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:4,0,1,1
    label: SCorr Threshold Low
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: '.93'
  states: {}
- name: tx_digital_gain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:3,0,1,1
    label: Digital Gain
    start: '0'
    step: '.1'
    stop: '10.'
    value: 2.7 / 2.7
  states: {}
- name: xcorr_threshold
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:3,0,1,1
    label: XCorr Threshold
    start: '0.0'
    step: '1'
    stop: '200.'
    value: '30.'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '60'
  states: {}
- name: analog_fastnoise_source_x_0
  id: analog_fastnoise_source_x
  parameters:
    amp: noise_voltage
    noise_type: analog.GR_GAUSSIAN
    samples: '8192'
    seed: '0'
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_0
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_add_xx_1
  id: blocks_add_xx
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: 1e9
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1'
  states: {state: disabled}
- name: blocks_message_strobe_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1'
  states: {state: disabled}
- name: blocks_message_strobe_0_0_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '1'
  states: {state: disabled}
- name: blocks_message_strobe_0_1
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '5'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {state: disabled}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: code_conf.info_byte_size - 15
    minsize: code_conf.info_byte_size - 15
  states: {}
- name: blocks_tag_debug_0_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: rx_len
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: fq_off
    noise_voltage: noise_voltage
    seed: '0'
    taps: chan_taps / np.sqrt(np.linalg.norm(chan_taps))
  states: {}
- name: channels_channel_model_0_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: fq_off
    noise_voltage: noise_voltage
    seed: '0'
    taps: (chan_taps / np.sqrt(np.linalg.norm(chan_taps))) * 0.7j
  states: {}
- name: ctrl_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,4,2,2
    label0: SDR Control
    label1: DSP Control
    num_tabs: '2'
  states: {}
- name: demod_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,3,6
    label0: Demodulation
    label1: Stats
    num_tabs: '2'
  states: {}
- name: gfdm_short_burst_shaper_0
  id: gfdm_short_burst_shaper
  parameters:
    cycle_interval: '0.00025'
    length_tag_name: '"packet_len"'
    minoutbuf: conf.padded_frame_len
    nports: len(conf.cyclic_shifts)
    post_padding: conf.post_padding_len
    pre_padding: conf.pre_padding_len
    scale: tx_digital_gain
    timing_advance: '0.001'
    use_timed_commands: 'False'
  states: {state: disabled}
- name: gfdm_transmitter_cc_0
  id: gfdm_transmitter_cc
  parameters:
    active_subcarriers: conf.active_subcarriers
    cp_len: conf.cp_len
    cs_len: conf.cs_len
    cyclic_shifts: conf.cyclic_shifts
    frequency_taps: conf.tx_filter_taps
    minoutbuf: conf.frame_len
    overlap: conf.overlap
    per_timeslot: 'True'
    preambles: conf.full_preambles
    ramp_len: conf.ramp_len
    subcarrier_map: conf.subcarrier_map
    subcarriers: conf.subcarriers
    timeslots: conf.timeslots
    tsb_tag_key: '"packet_len"'
    window_taps: conf.window_taps
  states: {state: disabled}
- name: hier_gfdm_fastsync_0
  id: hier_gfdm_fastsync
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    cp_len: conf.cp_len
    frame_len: conf.frame_len
    output_tag_key: '"frame_start"'
    ref_preamble: conf.core_preamble
    sc_high_thr: scorr_threshold_high
    sc_low_thr: scorr_threshold_low
    xcorr_comp_freq: '1'
    xcorr_det_thr: xcorr_threshold
  states: {state: disabled}
- name: hier_gfdm_receiver_tagged_0
  id: hier_gfdm_receiver_tagged
  parameters:
    active_subcarriers: conf.active_subcarriers
    compensate_phase: phase_compensate
    cp_len: conf.cp_len
    cs_len: conf.cs_len
    frame_len: conf.frame_len
    frame_start_tag_key: '"frame_start"'
    gfdm_constellation: gfdm_constellation
    ic_iterations: ic_iter_range
    overlap: conf.overlap
    preamble: conf.core_preamble
    ramp_len: conf.ramp_len
    rx_filter_taps: conf.rx_filter_taps
    subcarrier_map: conf.subcarrier_map
    subcarriers: conf.subcarriers
    timeslots: conf.timeslots
    which_estimator: '1'
  states: {state: disabled}
- name: hier_polar_decoder_0
  id: hier_polar_decoder
  parameters:
    frame_size: code_conf.frame_size
    frozen_bit_positions: code_conf.frozen_bit_positions
    info_size: code_conf.info_size
    interleaver_indices: code_conf.interleaver_indices
    length_tag_key: rx_len
    list_size: '4'
  states: {}
- name: hier_polar_encoder_0
  id: hier_polar_encoder
  parameters:
    frame_size: code_conf.frame_size
    frozen_bit_positions: code_conf.frozen_bit_positions
    interleaver_indices: code_conf.interleaver_indices
    length_tag_key: '"packet_len"'
  states: {state: disabled}
- name: hier_qt_live_statistics_0
  id: hier_qt_live_statistics
  parameters:
    gui_hint: 'live_stats@0: 0,0,3,7'
    histogram_val_string: histogram_val
    latency: latency
    missed_frames: missed_frames
    rx_frame: rx_frame
  states: {state: disabled}
- name: hier_qt_statistics_0
  id: hier_qt_statistics
  parameters:
    active_subcarriers: conf.active_subcarriers
    constel_order: gfdm_constellation.bits_per_symbol()
    frame_len: conf.frame_len
    gui_hint: 'demod_tab@1: 2,0,3,3'
    samp_rate: samp_rate
    subcarriers: conf.subcarriers
    timeslots: conf.timeslots
  states: {}
- name: import_gfdm_config
  id: import
  parameters:
    imports: from gfdm.pygfdm import get_gfdm_configuration
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_numpy_0
  id: import
  parameters:
    imports: import polarwrap
  states: {}
- name: latency_tag_timestamp_debug_0_0_0_0
  id: latency_tag_timestamp_debug
  parameters:
    key_name: '"time"'
    name: modulator
    num_inputs: '1'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: latency_tag_timestamp_debug_0_0_0_0_0
  id: latency_tag_timestamp_debug
  parameters:
    key_name: '"time"'
    name: tx
    num_inputs: '1'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: latency_tag_timestamp_debug_0_0_0_0_0_0
  id: latency_tag_timestamp_debug
  parameters:
    key_name: '"time"'
    name: synced
    num_inputs: '1'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: latency_tag_timestamp_debug_0_0_0_0_0_0_1
  id: latency_tag_timestamp_debug
  parameters:
    key_name: '"time"'
    name: demodulator
    num_inputs: '1'
    type: complex
    vlen: '1'
  states: {state: disabled}
- name: live_stats
  id: qtgui_tab_widget
  parameters:
    gui_hint: demod_tab@1:0,0,2,2
    label0: Live Stats
    num_tabs: '1'
  states: {}
- name: overlap
  id: parameter
  parameters:
    label: Overlap
    type: intx
    value: '2'
  states: {}
- name: qtgui_const_sink_rx_symbols
  id: qtgui_const_sink_x
  parameters:
    alias: '"constellation_sink"'
    color1: '"green"'
    grid: 'True'
    gui_hint: 'demod_tab@0: 0,0,2,2'
    legend: 'False'
    name: '"RX Constellation"'
    size: timeslots * active_subcarriers
    type: complex
    update_time: '0.30'
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: qtgui_time_sink_channel_estimate_0
  id: qtgui_time_sink_x
  parameters:
    alias: '"channel_sink"'
    axislabels: 'False'
    grid: 'True'
    gui_hint: 'demod_tab@0: 0, 2, 1, 2'
    label1: magnitude
    name: '"Channel Estimate"'
    size: conf.block_len
    srate: samp_rate * 0 + 1
    tr_level: '0.05'
    tr_tag: '"frame_start"'
    type: float
    update_time: '0.1'
    width1: '4'
    ymax: '2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_synced_stream
  id: qtgui_time_sink_x
  parameters:
    alias: '"sync_time_sink"'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'sync_tab@0: 0, 0, 1,1'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    legend: 'False'
    name: '"synchronization"'
    nconnections: '2'
    size: int(samp_rate / 500)
    srate: samp_rate
    tr_delay: '30e-6'
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.4'
    ymax: '.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_synced_stream_0
  id: qtgui_time_sink_x
  parameters:
    alias: '"sync_time_sink"'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'sync_tab@0: 0, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"transmitter"'
    size: int(samp_rate / 500)
    srate: samp_rate
    tr_delay: '30e-6'
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"packet_len"'
    type: complex
    update_time: '0.4'
    ymax: '.1'
    ymin: '-.1'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0
  id: qtgui_time_sink_x
  parameters:
    alias: '"latency_sink"'
    entags: 'False'
    grid: 'True'
    gui_hint: 'sync_tab@0: 1, 0, 1,1'
    label1: ''
    legend: 'False'
    name: '"Frame Latency"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Latency
    ymax: '5e-3'
    ymin: '0.0'
    yunit: '"s"'
  states: {}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'sync_tab@0: 2, 0, 1,1'
    label1: ''
    legend: 'False'
    name: '"SNR"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: SNR [dB]
    ymax: '5e-3'
    ymin: '0.0'
    yunit: '"packet"'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'demod_tab@0: 1, 2, 1, 2'
    label1: ''
    legend: 'False'
    name: '"SNR"'
    size: '1024'
    srate: samp_rate / samp_rate
    type: float
    ylabel: SNR [dB]
    ymax: '5e-3'
    ymin: '0.0'
    yunit: '"packet"'
  states: {}
- name: qtgui_waterfall_sink_x_0
  id: qtgui_waterfall_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: complex
  states: {state: disabled}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 15.625e6
  states: {state: disabled}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: symbolmapping_symbol_demapper_cf_0
  id: symbolmapping_symbol_demapper_cf
  parameters:
    constellation_order: gfdm_constellation.bits_per_symbol()
    constellation_type: GRAY
    snr_tag_name: cnr
  states: {state: disabled}
- name: symbolmapping_symbol_mapper_bc_0
  id: symbolmapping_symbol_mapper_bc
  parameters:
    constellation_order: gfdm_constellation.bits_per_symbol()
    constellation_type: GRAY
    is_packed: 'True'
  states: {state: disabled}
- name: sync_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,4,4
    label0: Synchronization
    num_tabs: '1'
  states: {}
- name: tacmac_elasticsearch_connector_0
  id: tacmac_elasticsearch_connector
  parameters:
    buffer_size: '300'
    data_type: 5gdata
    device_id: '4711'
    hostname: localhost
    index_prefix: measurements-
    port: '9200'
  states: {}
- name: tacmac_lower_phy_receiver_0
  id: tacmac_lower_phy_receiver
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    activate_phase_compensation: phase_compensate
    active_subcarriers: conf.active_subcarriers
    constellation: gfdm_constellation
    cp_len: conf.cp_len
    cs_len: conf.cs_len
    frequency_domain_taps: conf.rx_filter_taps
    ic_iterations: ic_iter_range
    nport: len(conf.cyclic_shifts)
    overlap: conf.overlap
    packet_length_key: '"frame_start"'
    preamble: conf.core_preamble
    ramp_len: conf.ramp_len
    scorr_threshold_high: scorr_threshold_high
    scorr_threshold_low: scorr_threshold_low
    subcarrier_map: conf.subcarrier_map
    subcarriers: conf.subcarriers
    timeslots: conf.timeslots
    xcorr_threshold: xcorr_threshold
  states: {}
- name: tacmac_mac_controller_0
  id: tacmac_mac_controller
  parameters:
    destination_id: '84'
    mtu_size: code_conf.info_byte_size - 15
    source_id: '42'
  states: {}
- name: tacmac_mac_controller_1
  id: tacmac_mac_controller
  parameters:
    destination_id: '42'
    mtu_size: code_conf.info_byte_size - 15
    source_id: '84'
  states: {}
- name: tacmac_phy_transmitter_0
  id: tacmac_phy_transmitter
  parameters:
    active_subcarriers: conf.active_subcarriers
    constellation_order: gfdm_constellation.base().bits_per_symbol()
    cp_len: conf.cp_len
    cs_len: conf.cs_len
    cycle_interval: '1e-4'
    cyclic_shift: conf.cyclic_shifts
    frame_size: code_conf.frame_size
    frequency_domain_taps: conf.tx_filter_taps
    frozen_bit_positions: code_conf.frozen_bit_positions
    full_preambles: conf.full_preambles
    interleaver_indices: code_conf.interleaver_indices
    overlap: conf.overlap
    packet_length_key: '"packet_len"'
    post_padding: conf.post_padding_len
    pre_padding: conf.pre_padding_len
    ramp_len: conf.ramp_len
    subcarrier_map: conf.subcarrier_map
    subcarriers: conf.subcarriers
    timeslots: conf.timeslots
    timing_advance: '250e-6'
    tx_digital_gain: tx_digital_gain
    window_taps: conf.window_taps
  states: {}
- name: tacmac_status_collector_0
  id: tacmac_status_collector
  parameters: {}
  states: {}
- name: tacmac_tag_to_stream_value_0_0
  id: tacmac_tag_to_stream_value
  parameters:
    dict_key: latency
    intype: byte
    type: int
    vlen: '1'
  states: {}
- name: tacmac_tag_to_stream_value_0_0_0
  id: tacmac_tag_to_stream_value
  parameters:
    dict_key: snr_lin
    intype: complex
    type: float
    vlen: '1'
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}

connections:
- [analog_fastnoise_source_x_0, '0', blocks_add_xx_0, '0']
- [blocks_add_xx_0, '0', hier_gfdm_fastsync_0, '0']
- [blocks_add_xx_1, '0', hier_gfdm_fastsync_0, '0']
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_channel_estimate_0, '0']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0_0, '0']
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_message_strobe_0_0, strobe, blocks_random_pdu_0, generate]
- [blocks_message_strobe_0_0_0, strobe, blocks_random_pdu_0, generate]
- [blocks_message_strobe_0_1, strobe, blocks_random_pdu_0, generate]
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_time_sink_x_0_0_0_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', hier_polar_encoder_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', tacmac_tag_to_stream_value_0_0, '0']
- [blocks_random_pdu_0, pdus, tacmac_mac_controller_0, LLCin]
- [blocks_tag_gate_0, '0', blocks_add_xx_0, '1']
- [blocks_tagged_stream_to_pdu_0, pdus, tacmac_mac_controller_1, PHYin]
- [blocks_tagged_stream_to_pdu_0, pdus, tacmac_status_collector_0, in]
- [channels_channel_model_0, '0', blocks_add_xx_1, '0']
- [channels_channel_model_0, '0', tacmac_lower_phy_receiver_0, '0']
- [channels_channel_model_0_0, '0', blocks_add_xx_1, '1']
- [channels_channel_model_0_0, '0', tacmac_lower_phy_receiver_0, '1']
- [gfdm_short_burst_shaper_0, '0', blocks_tag_gate_0, '0']
- [gfdm_short_burst_shaper_0, '0', channels_channel_model_0, '0']
- [gfdm_short_burst_shaper_0, '0', latency_tag_timestamp_debug_0_0_0_0_0, '0']
- [gfdm_short_burst_shaper_0, '0', qtgui_time_sink_synced_stream_0, '0']
- [gfdm_short_burst_shaper_0, '1', channels_channel_model_0_0, '0']
- [gfdm_transmitter_cc_0, '0', gfdm_short_burst_shaper_0, '0']
- [gfdm_transmitter_cc_0, '0', latency_tag_timestamp_debug_0_0_0_0, '0']
- [gfdm_transmitter_cc_0, '1', gfdm_short_burst_shaper_0, '1']
- [hier_gfdm_fastsync_0, '0', hier_gfdm_receiver_tagged_0, '0']
- [hier_gfdm_fastsync_0, '0', latency_tag_timestamp_debug_0_0_0_0_0_0, '0']
- [hier_gfdm_fastsync_0, '1', qtgui_freq_sink_x_0, '0']
- [hier_gfdm_fastsync_0, '1', qtgui_time_sink_synced_stream, '0']
- [hier_gfdm_fastsync_0, '1', qtgui_waterfall_sink_x_0, '0']
- [hier_gfdm_fastsync_0, '2', qtgui_time_sink_synced_stream, '1']
- [hier_gfdm_receiver_tagged_0, '0', blocks_complex_to_mag_0, '0']
- [hier_gfdm_receiver_tagged_0, '0', blocks_tag_debug_0_0, '0']
- [hier_gfdm_receiver_tagged_0, '0', tacmac_tag_to_stream_value_0_0_0, '0']
- [hier_gfdm_receiver_tagged_0, '1', latency_tag_timestamp_debug_0_0_0_0_0_0_1, '0']
- [hier_gfdm_receiver_tagged_0, '1', qtgui_const_sink_rx_symbols, '0']
- [hier_gfdm_receiver_tagged_0, '1', symbolmapping_symbol_demapper_cf_0, '0']
- [hier_polar_decoder_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [hier_polar_encoder_0, '0', symbolmapping_symbol_mapper_bc_0, '0']
- [symbolmapping_symbol_demapper_cf_0, '0', hier_polar_decoder_0, '0']
- [symbolmapping_symbol_mapper_bc_0, '0', gfdm_transmitter_cc_0, '0']
- [tacmac_lower_phy_receiver_0, '0', hier_polar_decoder_0, '0']
- [tacmac_lower_phy_receiver_0, '3', qtgui_time_sink_synced_stream, '1']
- [tacmac_lower_phy_receiver_0, '5', qtgui_time_sink_synced_stream, '0']
- [tacmac_lower_phy_receiver_0, '7', blocks_complex_to_mag_0, '0']
- [tacmac_lower_phy_receiver_0, '7', tacmac_tag_to_stream_value_0_0_0, '0']
- [tacmac_lower_phy_receiver_0, '9', qtgui_const_sink_rx_symbols, '0']
- [tacmac_mac_controller_0, PHYout, blocks_pdu_to_tagged_stream_0, pdus]
- [tacmac_mac_controller_0, PHYout, tacmac_phy_transmitter_0, pdus]
- [tacmac_mac_controller_1, LLCout, blocks_message_debug_0, print_pdu]
- [tacmac_mac_controller_1, LLCout, blocks_pdu_to_tagged_stream_0_0, pdus]
- [tacmac_phy_transmitter_0, '0', channels_channel_model_0, '0']
- [tacmac_phy_transmitter_0, '1', channels_channel_model_0_0, '0']
- [tacmac_status_collector_0, out, tacmac_elasticsearch_connector_0, in]
- [tacmac_tag_to_stream_value_0_0, '0', blocks_int_to_float_0, '0']
- [tacmac_tag_to_stream_value_0_0_0, '0', blocks_nlog10_ff_0_0, '0']

metadata:
  file_format: 1
