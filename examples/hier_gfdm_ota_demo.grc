options:
  parameters:
    author: Johannes Demel
    category: '[PolarGFDM]'
    generate_options: hb
    id: hier_gfdm_ota_demo
    max_nouts: '2048'
    output_language: python
    realtime_scheduling: '1'
    title: PolarGFDM over-the-air demo
  states: {}

blocks:
- name: active_bandwidth
  id: variable
  parameters:
    value: 1.0 * samp_rate * active_subcarriers / subcarriers
  states: {}
- name: code_conf
  id: variable
  parameters:
    comment: All coding related values are stored here
    value: polarwrap.get_polar_configuration(gfdm_constellation.bits_per_symbol() * timeslots * active_subcarriers, info_length, interleaver_type='convolutional')
  states: {}
- name: conf
  id: variable
  parameters:
    comment: All modulation configuration values are available here
    value: get_gfdm_configuration(timeslots, subcarriers, active_subcarriers, overlap=2, cp_len=16, cs_len=8, filtertype='rrc', filteralpha=0.2, cyclic_shifts=[0, 2, ])
  states: {}
- name: device_args
  id: variable
  parameters:
    value: '"master_clock_rate=125e6,send_frame_size=1024,send_buff_size=16384"'
  states: {state: disabled}
- name: device_args
  id: variable
  parameters:
    value: '"master_clock_rate=122.88e6,clock_source=gpsdo,time_source=gpsdo"'
  states: {}
- name: device_args
  id: variable
  parameters:
    value: '""'
  states: {state: disabled}
- name: frame_gap
  id: variable
  parameters:
    value: '2048'
  states: {state: disabled}
- name: frame_gap
  id: variable
  parameters:
    value: np.zeros(int(1. * samp_rate / 1000.) - conf.frame_len)
  states: {state: disabled}
- name: full_rx_device_addr
  id: variable
  parameters:
    value: ''',''.join([f''addr{i}={a}'' for i, a in enumerate(rx_addr.replace('','', '' '').split())])'
  states: {}
- name: full_tx_device_addr
  id: variable
  parameters:
    value: ''',''.join([f''addr{i}={a}'' for i, a in enumerate(tx_addr.replace('','', '' '').split())])'
  states: {}
- name: gfdm_constellation
  id: variable_constellation
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6 * 1
  states: {}
- name: usrp_initial_info
  id: variable
  parameters:
    value: '{"mboard_id": "NA", "mboard_serial": "NA", "mboard_name": "NA", "subdev": "NA", "ant": "NA", "rx_antenna": "NA", "tx_antenna": "NA"}'
  states: {}
- name: activate_cfo_compensation
  id: parameter
  parameters:
    label: Activate CFO compensation
    type: intx
    value: '1'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '60'
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: /home/johannes/Documents/gfdm_transmit_jose_001.cdat
    type: complex
  states: {state: disabled}
- name: blocks_file_sink_0_0
  id: blocks_file_sink
  parameters:
    file: /home/johannes/Documents/gfdm_recording_jose_001.cdat
    type: complex
  states: {state: disabled}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {state: disabled}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: complex
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: rx_len
    type: byte
  states: {}
- name: channels_channel_model_0
  id: channels_channel_model
  parameters:
    block_tags: 'True'
    epsilon: '1.0'
    freq_offset: '0.0'
    noise_voltage: '0.01'
    seed: '0'
    taps: '[1.,]'
  states: {state: disabled}
- name: cycle_interval
  id: parameter
  parameters:
    label: Cycle interval
    type: eng_float
    value: '320.e-6'
  states: {}
- name: db_device_id
  id: parameter
  parameters:
    label: DB device ID
    type: intx
    value: '4711'
  states: {}
- name: db_hostname
  id: parameter
  parameters:
    label: DB hostname
    type: str
    value: localhost
  states: {}
- name: dst_id
  id: parameter
  parameters:
    label: Destination ID
    type: intx
    value: '42'
  states: {}
- name: frame_gap_vector_insert
  id: blocks_vector_insert_x
  parameters:
    offset: '0'
    period: 2048+ len(frame_gap)
    type: complex
    vector: frame_gap
  states: {state: disabled}
- name: hier_gfdm_2rx_lower_phy_receiver_0
  id: hier_gfdm_2rx_lower_phy_receiver
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    active_subcarriers: conf.active_subcarriers
    cp_len: conf.cp_len
    cs_len: conf.cs_len
    frequency_domain_taps: conf.rx_filter_taps
    gfdm_constellation: gfdm_constellation
    ic_iterations: ic_iter_range
    overlap: conf.overlap
    phase_compensate: phase_compensate
    preamble: conf.core_preamble
    ramp_len: conf.ramp_len
    scorr_threshold_high: scorr_threshold_high
    scorr_threshold_low: scorr_threshold_low
    subcarrier_map: conf.subcarrier_map
    subcarriers: conf.subcarriers
    tag_key: frame_start
    timeslots: conf.timeslots
    xcorr_threshold: xcorr_threshold
  states: {state: disabled}
- name: hier_gfdm_phy_transmitter_0
  id: hier_gfdm_phy_transmitter
  parameters:
    active_subcarriers: conf.active_subcarriers
    cp_len: conf.cp_len
    cs_len: conf.cs_len
    cycle_interval: cycle_interval
    cyclic_shift: conf.cyclic_shifts
    frame_size: code_conf.frame_size
    frequency_domain_taps: conf.tx_filter_taps
    frozen_bit_positions: code_conf.frozen_bit_positions
    full_preambles: conf.full_preambles
    gfdm_constellation: gfdm_constellation
    interleaver_indices: code_conf.interleaver_indices
    overlap: conf.overlap
    post_padding: conf.post_padding_len
    pre_padding: conf.pre_padding_len
    ramp_len: conf.ramp_len
    subcarrier_map: conf.subcarrier_map
    subcarriers: conf.subcarriers
    tag_key: packet_len
    timeslots: conf.timeslots
    timing_advance: timing_advance
    tx_digital_gain: tx_digital_gain
    window_taps: conf.window_taps
  states: {state: disabled}
- name: hier_polar_decoder_0
  id: hier_polar_decoder
  parameters:
    frame_size: code_conf.frame_size
    frozen_bit_positions: code_conf.frozen_bit_positions
    info_size: code_conf.info_size
    interleaver_indices: code_conf.interleaver_indices
    length_tag_key: '"rx_len"'
    list_size: '4'
  states: {}
- name: ic_iter_range
  id: parameter
  parameters:
    label: IC iterations
    type: intx
    value: '2'
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: import_numpy_0
  id: import
  parameters:
    imports: import polarwrap
  states: {}
- name: import_numpy_0_0
  id: import
  parameters:
    imports: from gfdm.pygfdm import get_gfdm_configuration
  states: {}
- name: info_length
  id: parameter
  parameters:
    label: Information bit length
    type: intx
    value: '728'
  states: {}
- name: nports
  id: parameter
  parameters:
    label: Num ports
    type: intx
    value: '1'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: LLCout
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: synced0
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0
  id: pad_sink
  parameters:
    label: synced1
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0_0
  id: pad_sink
  parameters:
    label: symbols1
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_0_1
  id: pad_sink
  parameters:
    label: estimate1
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_1
  id: pad_sink
  parameters:
    label: symbols0
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_1_0
  id: pad_sink
  parameters:
    label: tx
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_0_2
  id: pad_sink
  parameters:
    label: estimate0
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: corr0
    optional: 'True'
    type: complex
  states: {}
- name: pad_sink_0_1_0
  id: pad_sink
  parameters:
    label: corr1
    optional: 'True'
    type: complex
  states: {}
- name: phase_compensate
  id: parameter
  parameters:
    label: Do phase compensation
    type: intx
    value: '1'
  states: {}
- name: qtgui_time_sink_detected_frames
  id: qtgui_time_sink_x
  parameters:
    gui_hint: 'sync_tab@0: 2, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"detected frames"'
    size: conf.frame_len * 3
    srate: samp_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.1'
  states: {state: disabled}
- name: qtgui_time_sink_synced_stream_0
  id: qtgui_time_sink_x
  parameters:
    alias: '"sync_time_sink"'
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'sync_tab@0: 0, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"LLRs"'
    nconnections: '2'
    size: timeslots * active_subcarriers * gfdm_constellation.bits_per_symbol()
    srate: samp_rate
    tr_delay: '30e-6'
    tr_level: '0.05'
    tr_tag: '"frame_start"'
    type: float
    update_time: '0.4'
    ymax: '.1'
    ymin: '-.1'
  states: {state: disabled}
- name: rgain
  id: parameter
  parameters:
    label: RX gain
    type: eng_float
    value: '38.'
  states: {}
- name: rx_addr
  id: parameter
  parameters:
    label: RX address
    type: str
    value: '"192.168.31.216"'
  states: {}
- name: scorr_threshold_high
  id: parameter
  parameters:
    label: SCorr higher threshold
    type: eng_float
    value: '.98'
  states: {}
- name: scorr_threshold_low
  id: parameter
  parameters:
    label: SC Lower threshold
    type: eng_float
    value: '.93'
  states: {}
- name: src_id
  id: parameter
  parameters:
    label: Source ID
    type: intx
    value: '0'
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: tacmac_elasticsearch_connector_0
  id: tacmac_elasticsearch_connector
  parameters:
    buffer_size: '5000'
    data_type: 5gdata
    device_id: db_device_id
    hostname: db_hostname
    index_prefix: measurements-
    port: '9200'
  states: {}
- name: tacmac_lower_phy_receiver_0
  id: tacmac_lower_phy_receiver
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    activate_phase_compensation: phase_compensate
    active_subcarriers: conf.active_subcarriers
    constellation: gfdm_constellation
    cp_len: conf.cp_len
    cs_len: conf.cs_len
    frequency_domain_taps: conf.rx_filter_taps
    ic_iterations: ic_iter_range
    nport: len(conf.cyclic_shifts)
    overlap: conf.overlap
    packet_length_key: '"frame_start"'
    preamble: conf.core_preamble
    ramp_len: conf.ramp_len
    scorr_threshold_high: scorr_threshold_high
    scorr_threshold_low: scorr_threshold_low
    subcarrier_map: conf.subcarrier_map
    subcarriers: conf.subcarriers
    timeslots: conf.timeslots
    xcorr_threshold: xcorr_threshold
  states: {}
- name: tacmac_periodic_time_tag_cc_0
  id: tacmac_periodic_time_tag_cc
  parameters:
    samp_rate: samp_rate
    tag_interval: int(samp_rate // 10000)
  states: {}
- name: tacmac_phy_transmitter_0
  id: tacmac_phy_transmitter
  parameters:
    active_subcarriers: conf.active_subcarriers
    constellation_order: gfdm_constellation.base().bits_per_symbol()
    cp_len: conf.cp_len
    cs_len: conf.cs_len
    cycle_interval: cycle_interval
    cyclic_shift: conf.cyclic_shifts
    frame_size: code_conf.frame_size
    frequency_domain_taps: conf.tx_filter_taps
    frozen_bit_positions: code_conf.frozen_bit_positions
    full_preambles: conf.full_preambles
    interleaver_indices: code_conf.interleaver_indices
    overlap: conf.overlap
    packet_length_key: '"packet_len"'
    post_padding: conf.post_padding_len
    pre_padding: conf.pre_padding_len
    ramp_len: conf.ramp_len
    subcarrier_map: conf.subcarrier_map
    subcarriers: conf.subcarriers
    timeslots: conf.timeslots
    timing_advance: timing_advance
    tx_digital_gain: tx_digital_gain
    window_taps: conf.window_taps
  states: {}
- name: tacmac_status_collector_0
  id: tacmac_status_collector
  parameters: {}
  states: {}
- name: tacmac_tags_to_msg_dict_0
  id: tacmac_tags_to_msg_dict
  parameters:
    intype: complex
    vlen: '1'
  states: {}
- name: tacmac_tags_to_msg_dict_0_0
  id: tacmac_tags_to_msg_dict
  parameters:
    intype: float
    vlen: '1'
  states: {state: disabled}
- name: tacmac_tags_to_msg_dict_0_0_0
  id: tacmac_tags_to_msg_dict
  parameters:
    intype: float
    vlen: '1'
  states: {state: disabled}
- name: tacmac_tags_to_msg_dict_0_0_1
  id: tacmac_tags_to_msg_dict
  parameters:
    intype: float
    vlen: '1'
  states: {state: disabled}
- name: tacmac_udp_interface_0
  id: tacmac_udp_interface
  parameters:
    dst_id: dst_id
    mtu_size: code_conf.info_byte_size - 15
    nports: nports
    src_id: src_id
  states: {}
- name: tfreq
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 3.75e9
  states: {}
- name: tgain
  id: parameter
  parameters:
    label: TX gain
    type: eng_float
    value: '65.'
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}
- name: timing_advance
  id: parameter
  parameters:
    label: Timing advance
    type: eng_float
    value: '.1e-5'
  states: {}
- name: tx_addr
  id: parameter
  parameters:
    label: TX address
    type: str
    value: '"192.168.31.216"'
  states: {}
- name: tx_digital_gain
  id: parameter
  parameters:
    label: Digital gain
    type: eng_float
    value: '2.7'
  states: {}
- name: uhd_usrp_sink_0
  id: uhd_usrp_sink
  parameters:
    ant0: '"TX/RX"'
    ant1: '"TX/RX"'
    center_freq0: tfreq
    center_freq1: tfreq
    clock_rate: 122.88e6
    clock_source0: gpsdo
    dev_addr: full_tx_device_addr
    dev_args: device_args
    gain0: tgain
    gain1: tgain
    len_tag_name: '"packet_len"'
    maxoutbuf: '4096'
    minoutbuf: '4096'
    nchan: '2'
    samp_rate: samp_rate
    stream_chans: '[2, 3,]'
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: uhd_usrp_source_0
  id: uhd_usrp_source
  parameters:
    ant0: '"RX2"'
    ant1: '"RX2"'
    center_freq0: tfreq
    center_freq1: tfreq
    clock_rate: 122.88e6
    clock_source0: gpsdo
    dc_offs_enb0: '""'
    dc_offs_enb1: '""'
    dev_addr: full_rx_device_addr
    dev_args: device_args
    gain0: rgain
    gain1: rgain
    iq_imbal_enb0: '""'
    iq_imbal_enb1: '""'
    nchan: '2'
    samp_rate: samp_rate
    stream_chans: '[0,1,]'
    sync: sync
    time_source0: gpsdo
    type: fc32
  states: {}
- name: xcorr_threshold
  id: parameter
  parameters:
    label: XCorr threshold
    type: eng_float
    value: '30.'
  states: {}

connections:
- [blocks_tagged_stream_to_pdu_0, pdus, pad_sink_0, in]
- [blocks_tagged_stream_to_pdu_0, pdus, tacmac_udp_interface_0, rx]
- [channels_channel_model_0, '0', hier_gfdm_2rx_lower_phy_receiver_0, '0']
- [channels_channel_model_0, '0', hier_gfdm_2rx_lower_phy_receiver_0, '1']
- [frame_gap_vector_insert, '0', channels_channel_model_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '0', pad_sink_0_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '1', pad_sink_0_0_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '10', pad_sink_0_1_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '2', pad_sink_0_0_1, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '3', hier_polar_decoder_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '3', tacmac_tags_to_msg_dict_0_0_1, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '4', qtgui_time_sink_synced_stream_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '4', tacmac_tags_to_msg_dict_0_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '5', qtgui_time_sink_synced_stream_0, '1']
- [hier_gfdm_2rx_lower_phy_receiver_0, '5', tacmac_tags_to_msg_dict_0_0_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '6', pad_sink_0_0_2, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '7', pad_sink_0_0_0_1, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '8', pad_sink_0_0_0_0, '0']
- [hier_gfdm_2rx_lower_phy_receiver_0, '9', pad_sink_0_1, '0']
- [hier_gfdm_phy_transmitter_0, '0', blocks_file_sink_0, '0']
- [hier_gfdm_phy_transmitter_0, '0', blocks_tag_debug_0, '0']
- [hier_gfdm_phy_transmitter_0, '0', frame_gap_vector_insert, '0']
- [hier_gfdm_phy_transmitter_0, '0', pad_sink_0_0_1_0, '0']
- [hier_gfdm_phy_transmitter_0, '0', tacmac_tags_to_msg_dict_0, '0']
- [hier_gfdm_phy_transmitter_0, '0', uhd_usrp_sink_0, '0']
- [hier_gfdm_phy_transmitter_0, '1', uhd_usrp_sink_0, '1']
- [hier_polar_decoder_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [tacmac_lower_phy_receiver_0, '0', hier_polar_decoder_0, '0']
- [tacmac_lower_phy_receiver_0, '10', pad_sink_0_0_0_0, '0']
- [tacmac_lower_phy_receiver_0, '3', pad_sink_0_1, '0']
- [tacmac_lower_phy_receiver_0, '4', pad_sink_0_1_0, '0']
- [tacmac_lower_phy_receiver_0, '5', pad_sink_0_0, '0']
- [tacmac_lower_phy_receiver_0, '6', pad_sink_0_0_0, '0']
- [tacmac_lower_phy_receiver_0, '7', pad_sink_0_0_2, '0']
- [tacmac_lower_phy_receiver_0, '8', pad_sink_0_0_0_1, '0']
- [tacmac_lower_phy_receiver_0, '9', pad_sink_0_0_1, '0']
- [tacmac_periodic_time_tag_cc_0, time_tag, hier_gfdm_phy_transmitter_0, time_tag]
- [tacmac_periodic_time_tag_cc_0, time_tag, tacmac_phy_transmitter_0, time_tag]
- [tacmac_phy_transmitter_0, '0', pad_sink_0_0_1_0, '0']
- [tacmac_phy_transmitter_0, '0', tacmac_tags_to_msg_dict_0, '0']
- [tacmac_phy_transmitter_0, '0', uhd_usrp_sink_0, '0']
- [tacmac_phy_transmitter_0, '1', uhd_usrp_sink_0, '1']
- [tacmac_status_collector_0, out, blocks_message_debug_0, print]
- [tacmac_status_collector_0, out, tacmac_elasticsearch_connector_0, in]
- [tacmac_tags_to_msg_dict_0, out, tacmac_status_collector_0, in]
- [tacmac_tags_to_msg_dict_0_0, out, blocks_message_debug_0, print]
- [tacmac_tags_to_msg_dict_0_0_0, out, blocks_message_debug_0, print]
- [tacmac_tags_to_msg_dict_0_0_1, out, blocks_message_debug_0, print]
- [tacmac_udp_interface_0, status, tacmac_status_collector_0, in]
- [tacmac_udp_interface_0, timing, hier_gfdm_phy_transmitter_0, time_tag]
- [tacmac_udp_interface_0, timing, tacmac_phy_transmitter_0, time_tag]
- [tacmac_udp_interface_0, tx, hier_gfdm_phy_transmitter_0, pdus]
- [tacmac_udp_interface_0, tx, tacmac_phy_transmitter_0, pdus]
- [uhd_usrp_source_0, '0', blocks_file_sink_0_0, '0']
- [uhd_usrp_source_0, '0', hier_gfdm_2rx_lower_phy_receiver_0, '0']
- [uhd_usrp_source_0, '0', tacmac_lower_phy_receiver_0, '0']
- [uhd_usrp_source_0, '0', tacmac_periodic_time_tag_cc_0, '0']
- [uhd_usrp_source_0, '1', hier_gfdm_2rx_lower_phy_receiver_0, '1']
- [uhd_usrp_source_0, '1', tacmac_lower_phy_receiver_0, '1']

metadata:
  file_format: 1
