options:
  parameters:
    author: Johannes Demel
    generate_options: no_gui
    id: gfdm_ota_demo_nogui
    max_nouts: '2048'
    output_language: python
    realtime_scheduling: '1'
    title: GFDM over-the-air demo headless
  states: {}

blocks:
- name: additional_db_data
  id: variable
  parameters:
    value: '{''rx_gain'': rx_gain, ''tx_gain'': tx_gain, ''timing_advance'': timing_advance, ''network_ports'': nports, ''tx_channels'': tx_channels, ''rx_channels'': rx_channels}'
  states: {}
- name: full_device_id
  id: variable
  parameters:
    value: db_device_id if db_device_id > 0 else 4200 + src_id
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6 * 1
  states: {}
- name: activate_cfo_compensation
  id: parameter
  parameters:
    label: Compesate CFO
    type: intx
    value: 'True'
  states: {}
- name: activate_phase_compensation
  id: parameter
  parameters:
    label: Compesate CFO
    type: intx
    value: '1'
  states: {}
- name: activate_replay_mode
  id: parameter
  parameters:
    label: Activate replay mdoe
    type: intx
    value: 'False'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '60'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: cycle_interval
  id: parameter
  parameters:
    label: Cycle interval
    type: eng_float
    value: '320.e-6'
  states: {}
- name: db_device_id
  id: parameter
  parameters:
    label: DB device ID
    type: intx
    value: '0'
  states: {}
- name: db_hostname
  id: parameter
  parameters:
    label: DB hostname
    type: str
    value: '"172.24.142.204"'
  states: {}
- name: dst_id
  id: parameter
  parameters:
    label: Destination ID
    type: intx
    value: '42'
  states: {}
- name: ic_iterations
  id: parameter
  parameters:
    label: IC iterations
    type: intx
    value: '2'
  states: {}
- name: master_clock_rate
  id: parameter
  parameters:
    label: Master clock rate
    type: eng_float
    value: 122.88e6
  states: {}
- name: mtu_size
  id: parameter
  parameters:
    label: MTU size
    type: intx
    value: '84'
  states: {}
- name: nports
  id: parameter
  parameters:
    label: Num ports
    type: intx
    value: '1'
  states: {}
- name: num_pilots
  id: parameter
  parameters:
    label: Number of pilot symbols
    type: intx
    value: '0'
  states: {}
- name: rx_addr
  id: parameter
  parameters:
    label: RX address
    type: str
    value: '""'
  states: {}
- name: rx_channels
  id: parameter
  parameters:
    label: 'RX channels, e.g. ''0 1'' '
    type: str
    value: '"0 1"'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: RX gain
    type: eng_float
    value: '55.'
  states: {}
- name: save_rx_to_file
  id: parameter
  parameters:
    label: Save RX samples to file (Yes > 0)
    type: intx
    value: '0'
  states: {}
- name: scorr_threshold_high
  id: parameter
  parameters:
    label: SCorr threshold high
    type: eng_float
    value: '.98'
  states: {}
- name: scorr_threshold_low
  id: parameter
  parameters:
    label: SCorr threshold low
    type: eng_float
    value: '.93'
  states: {}
- name: src_id
  id: parameter
  parameters:
    label: Source ID
    type: intx
    value: '0'
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: tacmac_elasticsearch_connector_0
  id: tacmac_elasticsearch_connector
  parameters:
    additional_data: additional_db_data
    buffer_size: '5000'
    data_type: 5gdata
    device_id: full_device_id
    hostname: db_hostname
    index_prefix: measurements-
    port: '9200'
  states: {}
- name: tacmac_phy_layer_0
  id: tacmac_phy_layer
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    activate_phase_compensation: activate_phase_compensation
    activate_replay_mode: activate_replay_mode > 0
    active_subcarriers: active_subcarriers
    carrier_freq: tfreq
    cycle_interval: cycle_interval
    dst_id: dst_id
    ic_iterations: ic_iterations
    master_clock_rate: master_clock_rate
    mtu_size: mtu_size
    num_network_interfaces: nports
    num_pilots: num_pilots
    rx_gain: rx_gain
    samp_rate: samp_rate
    save_rx_samples_to_file: save_rx_to_file > 0
    scorr_threshold_high: scorr_threshold_high
    scorr_threshold_low: scorr_threshold_low
    src_id: src_id
    subcarriers: subcarriers
    timeslots: timeslots
    timing_advance: timing_advance
    tx_digital_gain: tx_digital_gain
    tx_gain: tx_gain
    use_timed_commands: use_timed_commands > 0
    usrp_rx_addr: rx_addr
    usrp_rx_channels: '[int(i) for i in rx_channels.split()]'
    usrp_tx_addr: tx_addr
    usrp_tx_channels: '[int(i) for i in tx_channels.split()]'
    xcorr_threshold: xcorr_threshold
  states: {}
- name: tfreq
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 3.75e9
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}
- name: timing_advance
  id: parameter
  parameters:
    label: Timing advance
    type: eng_float
    value: '1.e-4'
  states: {}
- name: tx_addr
  id: parameter
  parameters:
    label: TX address
    type: str
    value: '""'
  states: {}
- name: tx_channels
  id: parameter
  parameters:
    label: TX channels, e.g. '2 3'
    type: str
    value: 2 3
  states: {}
- name: tx_digital_gain
  id: parameter
  parameters:
    label: TX digital gain
    type: eng_float
    value: '2.7'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: TX gain
    type: eng_float
    value: '55.'
  states: {}
- name: use_timed_commands
  id: parameter
  parameters:
    label: Use timed commands
    type: intx
    value: '1'
  states: {}
- name: xcorr_threshold
  id: parameter
  parameters:
    label: XCorr threshold
    type: eng_float
    value: '30.'
  states: {}

connections:
- [tacmac_phy_layer_0, '0', blocks_null_sink_0, '0']
- [tacmac_phy_layer_0, status, tacmac_elasticsearch_connector_0, in]

metadata:
  file_format: 1
  grc_version: 3.10.2.0
