options:
  parameters:
    author: Johannes Demel
    generate_options: no_gui
    id: gfdm_ota_demo_nogui
    max_nouts: '2048'
    output_language: python
    realtime_scheduling: '1'
    title: GFDM over-the-air demo headless
  states: {}

blocks:
- name: active_bandwidth
  id: variable
  parameters:
    value: 1.0 * samp_rate * active_subcarriers / subcarriers
  states: {}
- name: full_rx_addr
  id: variable
  parameters:
    value: rx_addr if len(rx_addr) > 0 else tx_addr
  states: {}
- name: info_length
  id: variable
  parameters:
    value: 8 * (mtu_size + 15)
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6 * 1
  states: {}
- name: tunnel_input_port
  id: variable
  parameters:
    value: f'40{dst_id:0>2}'
  states: {}
- name: tunnel_output_port
  id: variable
  parameters:
    value: f'40{src_id:0>2}'
  states: {}
- name: activate_cfo_compensation
  id: parameter
  parameters:
    label: Compesate CFO
    type: intx
    value: '1'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '60'
  states: {}
- name: blocks_null_sink_0
  id: blocks_null_sink
  parameters:
    type: complex
  states: {}
- name: blocks_socket_pdu_input
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: mtu_size
    port: tunnel_input_port
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_output
  id: blocks_socket_pdu
  parameters:
    host: localhost
    mtu: mtu_size
    port: tunnel_output_port
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: cycle_interval
  id: parameter
  parameters:
    label: Cycle interval
    type: eng_float
    value: '320.e-6'
  states: {}
- name: dst_id
  id: parameter
  parameters:
    label: Destination ID
    type: intx
    value: '42'
  states: {}
- name: hier_gfdm_ota_demo_0
  id: hier_gfdm_ota_demo
  parameters:
    activate_cfo_compensation: phase_compensate
    active_subcarriers: active_subcarriers
    cycle_interval: cycle_interval
    dst_id: dst_id
    ic_iter_range: ic_iter_range
    info_length: info_length
    phase_compensate: phase_compensate
    rgain: rx_gain
    rx_addr: full_rx_addr
    scorr_threshold_high: scorr_threshold_high
    scorr_threshold_low: scorr_threshold_low
    src_id: src_id
    subcarriers: subcarriers
    tfreq: tfreq
    tgain: tx_gain
    timeslots: timeslots
    timing_advance: timing_advance
    tx_addr: tx_addr
    tx_digital_gain: tx_digital_gain
    xcorr_threshold: xcorr_threshold
  states: {}
- name: ic_iter_range
  id: parameter
  parameters:
    label: IC iterations
    type: intx
    value: '2'
  states: {}
- name: info_length
  id: parameter
  parameters:
    label: Information bit length
    type: intx
    value: '792'
  states: {state: disabled}
- name: mtu_size
  id: parameter
  parameters:
    label: MTU size
    type: intx
    value: '84'
  states: {}
- name: phase_compensate
  id: parameter
  parameters:
    label: Compesate phase
    type: intx
    value: '1'
  states: {}
- name: rx_addr
  id: parameter
  parameters:
    label: RX address
    type: str
    value: '""'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: RX gain
    type: eng_float
    value: '55.'
  states: {}
- name: samp_rate
  id: parameter
  parameters:
    label: Sample rate
    type: eng_float
    value: 15.625e6
  states: {state: disabled}
- name: scorr_threshold_high
  id: parameter
  parameters:
    label: SCorr threshold high
    type: eng_float
    value: '.98'
  states: {}
- name: scorr_threshold_low
  id: parameter
  parameters:
    label: SCorr threshold low
    type: eng_float
    value: '.93'
  states: {}
- name: src_id
  id: parameter
  parameters:
    label: Source ID
    type: intx
    value: '0'
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: tfreq
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 3.75e9
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}
- name: timing_advance
  id: parameter
  parameters:
    label: Timing advance
    type: eng_float
    value: '1.e-4'
  states: {}
- name: tx_addr
  id: parameter
  parameters:
    label: TX address
    type: str
    value: '"192.168.31.216"'
  states: {}
- name: tx_digital_gain
  id: parameter
  parameters:
    label: TX digital gain
    type: eng_float
    value: '2.7'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: TX gain
    type: eng_float
    value: '55.'
  states: {}
- name: xcorr_threshold
  id: parameter
  parameters:
    label: XCorr threshold
    type: eng_float
    value: '30.'
  states: {}

connections:
- [blocks_socket_pdu_input, pdus, hier_gfdm_ota_demo_0, LLCin]
- [hier_gfdm_ota_demo_0, '4', blocks_null_sink_0, '0']
- [hier_gfdm_ota_demo_0, LLCout, blocks_socket_pdu_output, pdus]

metadata:
  file_format: 1
