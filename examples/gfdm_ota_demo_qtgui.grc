options:
  parameters:
    author: Johannes Demel
    generate_options: qt_gui
    id: gfdm_ota_demo_qtgui
    max_nouts: '2048'
    output_language: python
    realtime_scheduling: '1'
    title: GFDM over-the-air Demo
  states: {}

blocks:
- name: activate_cfo_compensation_gui
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: ctrl_tab@1:2,0,1,1
    label: compensate CFO
    'true': '1'
    type: int
    value: activate_cfo_compensation
  states: {}
- name: conf
  id: variable
  parameters:
    comment: All modulation configuration values are available here
    value: get_gfdm_configuration(timeslots, subcarriers, active_subcarriers, overlap=2, cp_len=16, cs_len=8, filtertype='rrc', filteralpha=0.2)
  states: {}
- name: cycle_interval_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:5,0,1,1
    label: TX cycle interval
    start: '70.e-6'
    step: '1.e-5'
    stop: '10.e-3'
    value: cycle_interval
  states: {}
- name: full_device_id
  id: variable
  parameters:
    value: db_device_id if db_device_id > 0 else 4200 + src_id
  states: {}
- name: gfdm_constellation
  id: variable_constellation
  parameters:
    const_points: '[-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j]'
    dims: '1'
    normalization: digital.constellation.AMPLITUDE_NORMALIZATION
    precision: '8'
    rot_sym: '4'
    sym_map: '[0, 1, 3, 2]'
    type: calcdist
  states: {}
- name: ic_iter_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:0,0,1,1
    label: IC Iterations
    min_len: '50'
    rangeType: int
    start: '0'
    step: '1'
    stop: '8'
    value: ic_iterations
  states: {}
- name: phase_compensate_gui
  id: variable_qtgui_check_box
  parameters:
    'false': '0'
    gui_hint: ctrl_tab@1:1,0,1,1
    label: compensate phase
    'true': '1'
    type: int
    value: activate_phase_compensation
  states: {}
- name: rgain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:1,0,1,1
    label: RX gain
    start: '0'
    step: '1'
    stop: '76'
    value: rx_gain
  states: {}
- name: rxdiprobe
  id: variable_function_probe
  parameters:
    block_id: uhd_usrp_source_0
    function_args: '0'
    function_name: get_usrp_info
    poll_rate: '0.1'
    value: usrp_initial_info
  states: {state: disabled}
- name: samp_rate
  id: variable
  parameters:
    value: 30.72e6 * 1
  states: {}
- name: scorr_threshold_high_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:5,0,1,1
    label: SCorr Threshold High
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: scorr_threshold_high
  states: {}
- name: scorr_threshold_low_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:4,0,1,1
    label: SCorr Threshold Low
    start: '0.0'
    step: '.01'
    stop: '1.'
    value: scorr_threshold_low
  states: {}
- name: tfreq_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:0,0,1,1
    label: Carrier Frequency
    start: 2.4e9
    step: '1'
    stop: 3.8e9
    value: tfreq
  states: {}
- name: tgain
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:2,0,1,1
    label: TX gain
    start: '0'
    step: '1'
    stop: '90'
    value: tx_gain
  states: {}
- name: timing_advance_gui
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:4,0,1,1
    label: Timing advance
    start: '0'
    step: '1.e-5'
    stop: '.05'
    value: timing_advance
  states: {}
- name: tx_digital_gain_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@0:3,0,1,1
    label: Digital Gain
    start: '0'
    step: '.1'
    stop: '10.'
    value: tx_digital_gain
  states: {}
- name: tx_gain_probed
  id: variable_function_probe
  parameters:
    block_id: tacmac_phy_layer_2x2
    function_name: get_tx_gain
    poll_rate: '10'
    value: '0'
  states: {state: disabled}
- name: uhd_version_info
  id: variable_qtgui_label
  parameters:
    gui_hint: 5,4,1,1
    label: UHD Version
    type: string
    value: uhd.get_version_string()
  states: {}
- name: usrp_device_info
  id: variable_qtgui_label
  parameters:
    formatter: 'lambda x: "{}:{}->{}".format(x[''mboard_id''], x[''mboard_serial''], x[''rx_antenna''])'
    gui_hint: 6,4,1,2
    label: RX Device Information
    type: raw
    value: rxdiprobe
  states: {state: disabled}
- name: usrp_initial_info
  id: variable
  parameters:
    value: '{"mboard_id": "NA", "mboard_serial": "NA", "mboard_name": "NA", "subdev": "NA", "ant": "NA", "rx_antenna": "NA", "tx_antenna": "NA"}'
  states: {}
- name: variable_qtgui_label_0
  id: variable_qtgui_label
  parameters:
    type: real
    value: tx_gain_probed
  states: {state: disabled}
- name: xcorr_threshold_range
  id: variable_qtgui_range
  parameters:
    gui_hint: ctrl_tab@1:3,0,1,1
    label: XCorr Threshold
    start: '0.0'
    step: '1'
    stop: '200.'
    value: xcorr_threshold
  states: {}
- name: activate_cfo_compensation
  id: parameter
  parameters:
    label: Compesate CFO
    type: intx
    value: 'True'
  states: {}
- name: activate_phase_compensation
  id: parameter
  parameters:
    label: Compesate CFO
    type: intx
    value: '1'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '60'
  states: {}
- name: blocks_complex_to_mag_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_0_0
  id: blocks_complex_to_mag
  parameters: {}
  states: {}
- name: blocks_complex_to_mag_squared_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_complex_to_mag_squared_0_0
  id: blocks_complex_to_mag_squared
  parameters: {}
  states: {state: disabled}
- name: blocks_float_to_complex_0
  id: blocks_float_to_complex
  parameters: {}
  states: {state: disabled}
- name: blocks_int_to_float_0
  id: blocks_int_to_float
  parameters:
    scale: 1e9
  states: {state: disabled}
- name: blocks_int_to_float_0_0
  id: blocks_int_to_float
  parameters:
    scale: '1'
  states: {}
- name: blocks_nlog10_ff_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_nlog10_ff_0_0
  id: blocks_nlog10_ff
  parameters:
    k: '0'
    n: '10'
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    num_inputs: '2'
    type: complex
  states: {state: disabled}
- name: ctrl_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,4,1,2
    label0: SDR Control
    label1: DSP Control
    num_tabs: '2'
  states: {}
- name: cycle_interval
  id: parameter
  parameters:
    label: Cycle interval
    type: eng_float
    value: '320.e-6'
  states: {}
- name: db_device_id
  id: parameter
  parameters:
    label: DB device ID
    type: intx
    value: '0'
  states: {}
- name: db_hostname
  id: parameter
  parameters:
    label: DB hostname
    type: str
    value: '"172.24.142.204"'
  states: {}
- name: demod_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 0,0,3,6
    label0: Demodulation
    label1: Stats
    num_tabs: '2'
  states: {}
- name: dst_id
  id: parameter
  parameters:
    label: Destination ID
    type: intx
    value: '42'
  states: {}
- name: hier_qt_statistics_0
  id: hier_qt_statistics
  parameters:
    active_subcarriers: conf.active_subcarriers
    constel_order: gfdm_constellation.bits_per_symbol()
    frame_len: conf.frame_len
    gui_hint: 'demod_tab@1: 2,0,3,3'
    samp_rate: samp_rate
    subcarriers: conf.subcarriers
    timeslots: conf.timeslots
  states: {state: disabled}
- name: ic_iterations
  id: parameter
  parameters:
    label: IC iterations
    type: intx
    value: '2'
  states: {}
- name: import_numpy_0
  id: import
  parameters:
    imports: import polarwrap
  states: {}
- name: import_numpy_0_0
  id: import
  parameters:
    imports: from gfdm.pygfdm import get_gfdm_configuration
  states: {}
- name: master_clock_rate
  id: parameter
  parameters:
    label: Master clock rate
    type: eng_float
    value: 122.88e6
  states: {}
- name: mtu_size
  id: parameter
  parameters:
    label: MTU size
    type: intx
    value: '84'
  states: {}
- name: nports
  id: parameter
  parameters:
    label: Num ports
    type: intx
    value: '1'
  states: {}
- name: qtgui_const_sink_rx_symbols
  id: qtgui_const_sink_x
  parameters:
    alias: '"constellation_sink"'
    color1: '"green"'
    grid: 'True'
    gui_hint: 'demod_tab@0: 0,0,2,2'
    legend: 'False'
    name: '"RX Constellation"'
    nconnections: '2'
    size: timeslots * active_subcarriers
    type: complex
    update_time: '0.30'
  states: {}
- name: qtgui_histogram_sink_x_0
  id: qtgui_histogram_sink_x
  parameters:
    accum: 'True'
    bins: '16'
    grid: 'True'
    gui_hint: 'demod_tab@1: 3,0,3,3'
    size: '1024'
    type: float
    xmax: '16'
    xmin: '1'
  states: {}
- name: qtgui_time_sink_channel_estimate_0
  id: qtgui_time_sink_x
  parameters:
    alias: '"channel_sink"'
    axislabels: 'False'
    entags: 'False'
    grid: 'True'
    gui_hint: 'demod_tab@0: 0, 2, 1, 2'
    label1: magnitude
    label2: phase
    legend: 'False'
    name: '"Channel Estimate magnitude"'
    nconnections: '2'
    size: conf.block_len
    srate: samp_rate * 0 + 1
    tr_level: '0.05'
    tr_tag: '"frame_start"'
    type: float
    update_time: '0.1'
    width1: '4'
    width2: '4'
    ymax: '2'
    ymin: '0'
  states: {}
- name: qtgui_time_sink_synced_stream
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'sync_tab@0: 0, 0, 1,1'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    label5: ''
    label6: ''
    legend: 'False'
    name: '"synchronization"'
    nconnections: '3'
    size: int(samp_rate / 500) * 2
    srate: samp_rate
    tr_delay: '30e-6'
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.4'
    ymax: '.1'
    ymin: '-.1'
  states: {state: disabled}
- name: qtgui_time_sink_synced_stream_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'sync_tab@0: 2, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"tx"'
    size: int(samp_rate / 500) * 2
    srate: samp_rate
    tr_delay: '30e-6'
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_AUTO
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.4'
    ymax: '.1'
    ymin: '-.1'
  states: {state: disabled}
- name: qtgui_time_sink_synced_stream_1
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'sync_tab@0: 0, 0, 1,1'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"synchronization"'
    size: int(2 ** 14)
    srate: samp_rate
    tr_level: '0.05'
    tr_mode: qtgui.TRIG_MODE_TAG
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.4'
    ymax: '.1'
    ymin: '-.1'
  states: {state: disabled}
- name: qtgui_time_sink_synced_stream_2
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    grid: 'True'
    gui_hint: 'sync_tab@0: 0, 0, 1,1'
    label1: ''
    label2: ''
    label3: ''
    label4: ''
    legend: 'False'
    name: '"synchronization"'
    nconnections: '2'
    size: '32'
    srate: samp_rate
    tr_delay: '0.0'
    tr_level: '0.05'
    tr_tag: '"frame_start"'
    type: complex
    update_time: '0.4'
    ymax: '.1'
    ymin: '-.1'
  states: {}
- name: qtgui_time_sink_x_0
  id: qtgui_time_sink_x
  parameters:
    alias: '"latency_sink"'
    entags: 'False'
    grid: 'True'
    gui_hint: 'sync_tab@0: 1, 0, 1,1'
    label1: ''
    legend: 'False'
    name: '"Frame Latency"'
    size: '1024'
    srate: samp_rate
    type: float
    ylabel: Latency
    ymax: '3e-3'
    ymin: '0.0'
    yunit: '"s"'
  states: {state: disabled}
- name: qtgui_time_sink_x_0_0_0
  id: qtgui_time_sink_x
  parameters:
    autoscale: 'True'
    entags: 'False'
    grid: 'True'
    gui_hint: 'demod_tab@0: 1, 2, 1, 2'
    label1: ''
    label2: ''
    legend: 'False'
    name: '"SNR"'
    nconnections: '2'
    size: '1024'
    srate: samp_rate / samp_rate
    type: float
    ylabel: SNR [dB]
    ymax: '5e-3'
    ymin: '0.0'
    yunit: '"packet"'
  states: {}
- name: rx_addr
  id: parameter
  parameters:
    label: RX address
    type: str
    value: '""'
  states: {}
- name: rx_channels
  id: parameter
  parameters:
    label: 'RX channels, e.g. ''0 1'' '
    type: str
    value: '"0 1"'
  states: {}
- name: rx_gain
  id: parameter
  parameters:
    label: RX gain
    type: eng_float
    value: '44.'
  states: {}
- name: save_rx_samples
  id: parameter
  parameters:
    label: 'Activate RX sample to file '
    type: intx
    value: '0'
  states: {}
- name: scorr_threshold_high
  id: parameter
  parameters:
    label: SCorr threshold high
    type: eng_float
    value: '.98'
  states: {}
- name: scorr_threshold_low
  id: parameter
  parameters:
    label: SCorr threshold low
    type: eng_float
    value: '.93'
  states: {}
- name: src_id
  id: parameter
  parameters:
    label: Source ID
    type: intx
    value: '0'
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: sync_tab
  id: qtgui_tab_widget
  parameters:
    gui_hint: 3,0,4,4
    label0: Synchronization
    num_tabs: '1'
  states: {}
- name: tacmac_elasticsearch_connector_0
  id: tacmac_elasticsearch_connector
  parameters:
    additional_data: '{}'
    buffer_size: '5000'
    data_type: 5gdata
    device_id: full_device_id
    hostname: db_hostname
    index_prefix: measurements-
    port: '9200'
  states: {state: disabled}
- name: tacmac_phy_layer_1x1
  id: tacmac_phy_layer
  parameters:
    activate_cfo_compensation: activate_cfo_compensation
    activate_phase_compensation: phase_compensate
    active_subcarriers: active_subcarriers
    carrier_freq: tfreq
    cycle_interval: cycle_interval
    dst_id: dst_id
    ic_iterations: ic_iter_range
    master_clock_rate: 122.88e6
    mtu_size: mtu_size
    num_network_interfaces: nports
    rx_gain: rgain
    samp_rate: samp_rate
    save_rx_samples_to_file: 'False'
    scorr_threshold_high: scorr_threshold_high
    scorr_threshold_low: scorr_threshold_low
    src_id: src_id
    subcarriers: subcarriers
    timeslots: timeslots
    timing_advance: timing_advance_gui
    tx_digital_gain: tx_digital_gain
    tx_gain: tgain
    usrp_rx_addr: rx_addr
    usrp_rx_channels: '[0, ]'
    usrp_tx_addr: tx_addr
    usrp_tx_channels: '[1,]'
    xcorr_threshold: xcorr_threshold
  states: {state: disabled}
- name: tacmac_phy_layer_2x2
  id: tacmac_phy_layer
  parameters:
    activate_cfo_compensation: activate_cfo_compensation_gui
    activate_phase_compensation: phase_compensate_gui
    active_subcarriers: active_subcarriers
    carrier_freq: tfreq_range
    cycle_interval: cycle_interval_range
    dst_id: dst_id
    ic_iterations: ic_iter_range
    master_clock_rate: master_clock_rate
    mtu_size: mtu_size
    num_network_interfaces: nports
    rx_gain: rgain
    samp_rate: samp_rate
    save_rx_samples_to_file: save_rx_samples
    scorr_threshold_high: scorr_threshold_high_range
    scorr_threshold_low: scorr_threshold_low_range
    src_id: src_id
    subcarriers: subcarriers
    timeslots: timeslots
    timing_advance: timing_advance_gui
    tx_digital_gain: tx_digital_gain_range
    tx_gain: tgain
    usrp_rx_addr: rx_addr
    usrp_rx_channels: '[int(i) for i in rx_channels.split()]'
    usrp_tx_addr: tx_addr
    usrp_tx_channels: '[int(i) for i in tx_channels.split()]'
    xcorr_threshold: xcorr_threshold_range
  states: {}
- name: tacmac_tag_to_stream_value_0
  id: tacmac_tag_to_stream_value
  parameters:
    dict_key: latency
    intype: byte
    tag_key: latency
    type: int
    vlen: '1'
  states: {state: disabled}
- name: tacmac_tag_to_stream_value_0_0
  id: tacmac_tag_to_stream_value
  parameters:
    dict_key: lost_packets
    intype: byte
    tag_key: lost_packets
    type: int
    vlen: '1'
  states: {}
- name: tacmac_tag_to_stream_value_0_0_0
  id: tacmac_tag_to_stream_value
  parameters:
    dict_key: snr_lin0
    intype: complex
    tag_key: snr_lin0
    type: float
    vlen: '1'
  states: {}
- name: tacmac_tag_to_stream_value_0_0_0_0
  id: tacmac_tag_to_stream_value
  parameters:
    dict_key: snr_lin1
    intype: complex
    tag_key: snr_lin1
    type: float
    vlen: '1'
  states: {}
- name: tacmac_tag_to_stream_value_0_0_1
  id: tacmac_tag_to_stream_value
  parameters:
    dict_key: sc_rot
    intype: complex
    tag_key: frame_start
    type: complex
    vlen: '1'
  states: {}
- name: tacmac_tag_to_stream_value_0_0_1_0
  id: tacmac_tag_to_stream_value
  parameters:
    dict_key: sc_rot
    intype: complex
    tag_key: frame_start
    type: complex
    vlen: '1'
  states: {}
- name: tfreq
  id: parameter
  parameters:
    label: Carrier frequency
    type: eng_float
    value: 3.75e9
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}
- name: timing_advance
  id: parameter
  parameters:
    label: Timing advance
    type: eng_float
    value: '2.e-4'
  states: {}
- name: tx_addr
  id: parameter
  parameters:
    label: TX address
    type: str
    value: '""'
  states: {}
- name: tx_channels
  id: parameter
  parameters:
    label: TX channels, e.g. '2 3'
    type: str
    value: 2 3
  states: {}
- name: tx_digital_gain
  id: parameter
  parameters:
    label: TX digital gain
    type: eng_float
    value: '2.7'
  states: {}
- name: tx_gain
  id: parameter
  parameters:
    label: TX gain
    type: eng_float
    value: '55.'
  states: {}
- name: xcorr_threshold
  id: parameter
  parameters:
    label: XCorr threshold
    type: eng_float
    value: '30.'
  states: {}

connections:
- [blocks_complex_to_mag_0, '0', qtgui_time_sink_channel_estimate_0, '0']
- [blocks_complex_to_mag_0_0, '0', qtgui_time_sink_channel_estimate_0, '1']
- [blocks_complex_to_mag_squared_0, '0', blocks_float_to_complex_0, '0']
- [blocks_complex_to_mag_squared_0_0, '0', blocks_float_to_complex_0, '1']
- [blocks_float_to_complex_0, '0', qtgui_time_sink_synced_stream, '2']
- [blocks_int_to_float_0, '0', qtgui_time_sink_x_0, '0']
- [blocks_int_to_float_0_0, '0', qtgui_histogram_sink_x_0, '0']
- [blocks_nlog10_ff_0, '0', qtgui_time_sink_x_0_0_0, '0']
- [blocks_nlog10_ff_0_0, '0', qtgui_time_sink_x_0_0_0, '1']
- [blocks_pdu_to_tagged_stream_0_0, '0', tacmac_tag_to_stream_value_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', tacmac_tag_to_stream_value_0_0, '0']
- [tacmac_phy_layer_1x1, '1', blocks_complex_to_mag_squared_0, '0']
- [tacmac_phy_layer_1x1, '1', blocks_complex_to_mag_squared_0_0, '0']
- [tacmac_phy_layer_1x1, '2', qtgui_time_sink_synced_stream, '0']
- [tacmac_phy_layer_1x1, '2', qtgui_time_sink_synced_stream, '1']
- [tacmac_phy_layer_1x1, '3', blocks_complex_to_mag_0, '0']
- [tacmac_phy_layer_1x1, '3', blocks_complex_to_mag_0_0, '0']
- [tacmac_phy_layer_1x1, '4', qtgui_const_sink_rx_symbols, '0']
- [tacmac_phy_layer_1x1, '4', qtgui_const_sink_rx_symbols, '1']
- [tacmac_phy_layer_1x1, '4', tacmac_tag_to_stream_value_0_0_0, '0']
- [tacmac_phy_layer_1x1, '4', tacmac_tag_to_stream_value_0_0_0_0, '0']
- [tacmac_phy_layer_1x1, LLCout, blocks_pdu_to_tagged_stream_0_0, pdus]
- [tacmac_phy_layer_2x2, '0', qtgui_time_sink_synced_stream_0, '0']
- [tacmac_phy_layer_2x2, '2', blocks_complex_to_mag_squared_0, '0']
- [tacmac_phy_layer_2x2, '3', blocks_complex_to_mag_squared_0_0, '0']
- [tacmac_phy_layer_2x2, '4', blocks_tag_debug_0, '0']
- [tacmac_phy_layer_2x2, '4', qtgui_time_sink_synced_stream, '0']
- [tacmac_phy_layer_2x2, '4', tacmac_tag_to_stream_value_0_0_1, '0']
- [tacmac_phy_layer_2x2, '5', blocks_tag_debug_0, '1']
- [tacmac_phy_layer_2x2, '5', qtgui_time_sink_synced_stream, '1']
- [tacmac_phy_layer_2x2, '5', tacmac_tag_to_stream_value_0_0_1_0, '0']
- [tacmac_phy_layer_2x2, '6', blocks_complex_to_mag_0, '0']
- [tacmac_phy_layer_2x2, '7', blocks_complex_to_mag_0_0, '0']
- [tacmac_phy_layer_2x2, '8', qtgui_const_sink_rx_symbols, '0']
- [tacmac_phy_layer_2x2, '8', tacmac_tag_to_stream_value_0_0_0, '0']
- [tacmac_phy_layer_2x2, '9', qtgui_const_sink_rx_symbols, '1']
- [tacmac_phy_layer_2x2, '9', tacmac_tag_to_stream_value_0_0_0_0, '0']
- [tacmac_phy_layer_2x2, LLCout, blocks_pdu_to_tagged_stream_0_0, pdus]
- [tacmac_phy_layer_2x2, status, tacmac_elasticsearch_connector_0, in]
- [tacmac_tag_to_stream_value_0_0, '0', blocks_int_to_float_0_0, '0']
- [tacmac_tag_to_stream_value_0_0_0, '0', blocks_nlog10_ff_0, '0']
- [tacmac_tag_to_stream_value_0_0_0_0, '0', blocks_nlog10_ff_0_0, '0']
- [tacmac_tag_to_stream_value_0_0_1, '0', qtgui_time_sink_synced_stream_2, '0']
- [tacmac_tag_to_stream_value_0_0_1_0, '0', qtgui_time_sink_synced_stream_2, '1']

metadata:
  file_format: 1
