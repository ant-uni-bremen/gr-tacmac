options:
  parameters:
    author: Johannes Demel
    category: '[GFDM]'
    generate_options: hb
    id: hier_gfdm_phy_transmitter
    output_language: python
    title: GFDM PHY transmitter
  states: {}

blocks:
- name: var_encoder
  id: variable_polarwrap_encoderwrap
  parameters:
    block_size: frame_size
    dim1: '1'
    dim2: '4'
    error_detection_type: '0'
    frozen_bit_positions: frozen_bit_positions
    ndim: '0'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '60'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: tag_key
    type: byte
  states: {}
- name: cp_len
  id: parameter
  parameters:
    label: CP length
    type: intx
    value: '16'
  states: {}
- name: cs_len
  id: parameter
  parameters:
    label: CS length
    type: intx
    value: '8'
  states: {}
- name: cycle_interval
  id: parameter
  parameters:
    label: Cycle interval
    type: eng_float
    value: '320.e-6'
  states: {}
- name: cyclic_shift
  id: parameter
  parameters:
    label: Cyclic shift
    value: '[0, 2, ]'
  states: {}
- name: fec_generic_encoder_0
  id: fec_generic_encoder
  parameters:
    encoder: var_encoder
    itype: byte
    otype: byte
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame size
    type: intx
    value: '1024'
  states: {}
- name: frequency_domain_taps
  id: parameter
  parameters:
    label: Frequency domain taps
    value: list(range(60))
  states: {}
- name: frozen_bit_positions
  id: parameter
  parameters:
    label: Frozen bit positions
    value: list(range(512))
  states: {}
- name: full_preambles
  id: parameter
  parameters:
    label: Full preambles
    value: '[list(range(146)), list(range(146)), ]'
  states: {}
- name: gfdm_constellation
  id: parameter
  parameters:
    label: Constellation object
    value: |-
      digital.constellation_calcdist([-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j], [0, 1, 3, 2],
      4, 1).base()
  states: {}
- name: gfdm_short_burst_shaper_0
  id: gfdm_short_burst_shaper
  parameters:
    cycle_interval: cycle_interval
    length_tag_name: tag_key
    nports: len(cyclic_shift)
    post_padding: post_padding
    pre_padding: pre_padding
    scale: tx_digital_gain
    timing_advance: timing_advance
    use_timed_commands: 'True'
  states: {}
- name: gfdm_transmitter_cc_0
  id: gfdm_transmitter_cc
  parameters:
    active_subcarriers: active_subcarriers
    cp_len: cp_len
    cs_len: cs_len
    cyclic_shifts: cyclic_shift
    frequency_taps: frequency_domain_taps
    overlap: overlap
    per_timeslot: 'True'
    preambles: full_preambles
    ramp_len: ramp_len
    subcarrier_map: subcarrier_map
    subcarriers: subcarriers
    timeslots: timeslots
    tsb_tag_key: tag_key
    window_taps: window_taps
  states: {}
- name: hier_polar_encoder_0
  id: hier_polar_encoder
  parameters:
    frame_size: frame_size
    frozen_bit_positions: frozen_bit_positions
    interleaver_indices: interleaver_indices
    length_tag_key: tag_key
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: interleaver_indices
  id: parameter
  parameters:
    label: Interleaver indices
    value: list(range(1024))
  states: {}
- name: overlap
  id: parameter
  parameters:
    label: Overlap
    type: intx
    value: '2'
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: out0
    type: complex
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: command
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: out1
    type: complex
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: pdus
    type: message
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: time_tag
    optional: 'True'
    type: message
  states: {}
- name: post_padding
  id: parameter
  parameters:
    label: Frame post-padding
    type: intx
    value: '128'
  states: {}
- name: pre_padding
  id: parameter
  parameters:
    label: Frame pre-padding
    type: intx
    value: '256'
  states: {}
- name: ramp_len
  id: parameter
  parameters:
    label: Ramp length
    type: intx
    value: '8'
  states: {}
- name: subcarrier_map
  id: parameter
  parameters:
    label: Subcarrier map
    value: list(range(60))
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: symbolmapping_interleaver_0
  id: symbolmapping_interleaver
  parameters:
    interleaver_indices: interleaver_indices
    interleaver_mode: interleave
    is_packed: '1'
    type: byte
  states: {}
- name: symbolmapping_symbol_mapper_bc_0
  id: symbolmapping_symbol_mapper_bc
  parameters:
    constellation_order: gfdm_constellation.bits_per_symbol()
    constellation_type: GRAY
    is_packed: 'True'
  states: {}
- name: tag_key
  id: parameter
  parameters:
    label: Tag key
    type: str
    value: packet_len
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}
- name: timing_advance
  id: parameter
  parameters:
    label: Timing advance
    type: eng_float
    value: '2.e-4'
  states: {}
- name: tx_digital_gain
  id: parameter
  parameters:
    label: Digital gain
    type: eng_float
    value: '2.7'
  states: {}
- name: window_taps
  id: parameter
  parameters:
    label: Window taps
    value: list(range(60))
  states: {}

connections:
- [blocks_pdu_to_tagged_stream_0, '0', fec_generic_encoder_0, '0']
- [fec_generic_encoder_0, '0', symbolmapping_interleaver_0, '0']
- [gfdm_short_burst_shaper_0, '0', pad_sink_0, '0']
- [gfdm_short_burst_shaper_0, '1', pad_sink_0_1, '0']
- [gfdm_short_burst_shaper_0, command, pad_sink_0_0, in]
- [gfdm_transmitter_cc_0, '0', gfdm_short_burst_shaper_0, '0']
- [gfdm_transmitter_cc_0, '1', gfdm_short_burst_shaper_0, '1']
- [pad_source_0, out, blocks_pdu_to_tagged_stream_0, pdus]
- [pad_source_0_0, out, gfdm_short_burst_shaper_0, time_tag]
- [symbolmapping_interleaver_0, '0', symbolmapping_symbol_mapper_bc_0, '0']
- [symbolmapping_symbol_mapper_bc_0, '0', gfdm_transmitter_cc_0, '0']

metadata:
  file_format: 1
