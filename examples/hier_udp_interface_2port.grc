options:
  parameters:
    author: Johannes Demel
    category: '[tacmac]'
    generate_options: hb
    id: hier_udp_interface_2port
    output_language: python
    title: 2 Port UDP Interface Example
  states: {}

blocks:
- name: mtu_size
  id: variable
  parameters:
    value: '84'
  states: {}
- name: phy_header_size
  id: variable
  parameters:
    value: '15'
  states: {}
- name: blocks_socket_pdu_0
  id: blocks_socket_pdu
  parameters:
    host: '"localhost"'
    mtu: mtu_size
    port: '4021'
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_socket_pdu_0_0
  id: blocks_socket_pdu
  parameters:
    host: '"localhost"'
    mtu: mtu_size
    port: '4042'
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: pad_sink_0
  id: pad_sink
  parameters:
    label: tx
    type: message
  states: {}
- name: pad_sink_0_0
  id: pad_sink
  parameters:
    label: status
    optional: 'True'
    type: message
  states: {}
- name: pad_sink_0_1
  id: pad_sink
  parameters:
    label: timing
    optional: 'True'
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: rx
    type: message
  states: {}
- name: tacmac_mac_controller_0
  id: tacmac_mac_controller
  parameters:
    destination_id: '42'
    mtu_size: mtu_size
    source_id: '21'
  states: {}
- name: tacmac_udp_interface_0
  id: tacmac_udp_interface
  parameters:
    dst_id: '42'
    mtu_size: '68'
    nports: '1'
    src_id: '21'
  states: {}

connections:
- [blocks_socket_pdu_0_0, pdus, tacmac_mac_controller_0, LLCin]
- [pad_source_0, out, tacmac_mac_controller_0, PHYin]
- [tacmac_mac_controller_0, LLCout, blocks_socket_pdu_0, pdus]
- [tacmac_mac_controller_0, LLCout, pad_sink_0_0, in]
- [tacmac_mac_controller_0, PHYout, pad_sink_0, in]
- [tacmac_mac_controller_0, timing, pad_sink_0_1, in]

metadata:
  file_format: 1
