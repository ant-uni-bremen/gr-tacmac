options:
  parameters:
    author: Johannes Demel
    generate_options: no_gui
    id: zmq_test
    output_language: python
    title: ZeroMQ loop test
  states: {}

blocks:
- name: zmq_pull_port
  id: variable
  parameters:
    value: '''55'' + str(dst_id)'
  states: {}
- name: zmq_push_port
  id: variable
  parameters:
    value: '''55'' + str(src_id)'
  states: {}
- name: zmq_receive_address
  id: variable
  parameters:
    value: '''tcp://'' + remote + '':5555'''
  states: {state: disabled}
- name: zmq_receive_address
  id: variable
  parameters:
    value: '''tcp://'' + remote + '':'' + zmq_pull_port'
  states: {}
- name: zmq_target_address
  id: variable
  parameters:
    value: '''tcp://'' + ''*'' + '':6666'''
  states: {state: disabled}
- name: zmq_target_address
  id: variable
  parameters:
    value: '''tcp://'' + ''*'' + '':'' + zmq_push_port'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("ZMQ-loop")
    v: pmt.intern("REMOTE")
  states: {}
- name: dst_id
  id: parameter
  parameters:
    label: destination ID aka PHY ID of remote
    type: intx
    value: '21'
  states: {}
- name: mtu_size
  id: parameter
  parameters:
    label: MTU size
    type: intx
    value: '68'
  states: {}
- name: remote
  id: parameter
  parameters:
    label: 0MQ remote IP
    type: str
    value: 127.0.0.1
  states: {}
- name: src_id
  id: parameter
  parameters:
    label: source ID aka PHY ID of host
    type: intx
    value: '42'
  states: {}
- name: tacmac_mac_controller_loopback
  id: tacmac_mac_controller
  parameters:
    destination_id: dst_id
    mtu_size: mtu_size
    source_id: src_id
  states: {}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    address: zmq_receive_address
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: zmq_target_address
    timeout: '100'
  states: {}
- name: zmq_remote
  id: parameter
  parameters:
    label: 0MQ remote IP
    type: str
    value: 127.0.0.1
  states: {state: disabled}

connections:
- [blocks_pdu_set_0, pdus, tacmac_mac_controller_loopback, LLCin]
- [tacmac_mac_controller_loopback, LLCout, blocks_pdu_set_0, pdus]
- [tacmac_mac_controller_loopback, PHYout, zeromq_push_msg_sink_0, in]
- [zeromq_pull_msg_source_0, out, blocks_message_debug_0, print_pdu]
- [zeromq_pull_msg_source_0, out, tacmac_mac_controller_loopback, PHYin]

metadata:
  file_format: 1
  grc_version: 3.9.7.0-rc1
