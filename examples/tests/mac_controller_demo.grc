options:
  parameters:
    author: Johannes Demel
    generate_options: no_gui
    id: mac_controller_demo
    output_language: python
    title: MAC controller demo
  states: {}

blocks:
- name: mtu_size
  id: variable
  parameters:
    value: '68'
  states: {}
- name: phy_header_size
  id: variable
  parameters:
    value: '15'
  states: {}
- name: blocks_message_debug_0_0_0_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_message_strobe_0
  id: blocks_message_strobe
  parameters:
    msg: pmt.intern("TEST")
    period: '250'
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_pdu_to_tagged_stream_0_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_random_pdu_0
  id: blocks_random_pdu
  parameters:
    length_modulo: '1'
    mask: '0xFF'
    maxsize: mtu_size
    minsize: mtu_size
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: mtu_size
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: mtu_size + phy_header_size
    type: byte
  states: {}
- name: blocks_tag_debug_0
  id: blocks_tag_debug
  parameters:
    type: byte
  states: {}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tag_gate_0_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {}
- name: tacmac_mac_controller_0
  id: tacmac_mac_controller
  parameters:
    destination_id: '42'
    mtu_size: '68'
    source_id: '21'
  states: {}
- name: tacmac_mac_controller_0_0
  id: tacmac_mac_controller
  parameters:
    destination_id: '21'
    mtu_size: '68'
    source_id: '42'
  states: {}

connections:
- [blocks_message_strobe_0, strobe, blocks_random_pdu_0, generate]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tag_gate_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_tag_debug_0, '0']
- [blocks_pdu_to_tagged_stream_0_0, '0', blocks_tag_gate_0_0, '0']
- [blocks_random_pdu_0, pdus, tacmac_mac_controller_0, LLCin]
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_stream_to_tagged_stream_0_0, '0', blocks_tagged_stream_to_pdu_0_0, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_tag_gate_0_0, '0', blocks_stream_to_tagged_stream_0_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, tacmac_mac_controller_0_0, LLCin]
- [blocks_tagged_stream_to_pdu_0_0, pdus, tacmac_mac_controller_0_0, PHYin]
- [tacmac_mac_controller_0, LLCout, blocks_message_debug_0_0_0_0, print_pdu]
- [tacmac_mac_controller_0, PHYout, blocks_pdu_to_tagged_stream_0_0, pdus]
- [tacmac_mac_controller_0, PHYout, tacmac_mac_controller_0, PHYin]
- [tacmac_mac_controller_0_0, LLCout, blocks_pdu_to_tagged_stream_0, pdus]
- [tacmac_mac_controller_0_0, PHYout, tacmac_mac_controller_0, PHYin]

metadata:
  file_format: 1
