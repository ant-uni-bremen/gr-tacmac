options:
  parameters:
    author: johannes
    generate_options: qt_gui
    id: elasticsearch_test
    output_language: python
    title: elasticsearch
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: qtgui_edit_box_msg_0
  id: qtgui_edit_box_msg
  parameters:
    key: '''foo'''
    label: '''foo'''
    type: string
    value: '''elastictest'''
  states: {}
- name: tacmac_elasticsearch_connector_0
  id: tacmac_elasticsearch_connector
  parameters:
    hostname: localhost
    port: '9200'
  states: {}

connections:
- [qtgui_edit_box_msg_0, msg, tacmac_elasticsearch_connector_0, in]

metadata:
  file_format: 1
