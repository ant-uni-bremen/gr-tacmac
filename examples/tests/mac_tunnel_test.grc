options:
  parameters:
    author: Johannes Demel
    generate_options: no_gui
    id: mac_tunnel_test
    output_language: python
    title: MAC Tunnel test
  states: {}

blocks:
- name: tunnel_input_port
  id: variable
  parameters:
    value: '''40'' + str(dst_id)'
  states: {}
- name: tunnel_output_port
  id: variable
  parameters:
    value: '''40'' + str(src_id)'
  states: {}
- name: zmq_pull_port
  id: variable
  parameters:
    value: '''55'' + str(dst_id)'
  states: {}
- name: zmq_push_port
  id: variable
  parameters:
    value: '''55'' + str(src_id)'
  states: {}
- name: zmq_receive_address
  id: variable
  parameters:
    value: '''tcp://'' + zmq_remote + '':'' + zmq_pull_port'
  states: {}
- name: zmq_target_address
  id: variable
  parameters:
    value: '''tcp://'' + ''*'' + '':'' + zmq_push_port'
  states: {}
- name: blocks_message_debug_0
  id: blocks_message_debug
  parameters: {}
  states: {}
- name: blocks_pdu_set_0
  id: blocks_pdu_set
  parameters:
    k: pmt.intern("ZMQ-Push")
    v: pmt.intern("PHYout")
  states: {}
- name: blocks_pdu_to_tagged_stream_0
  id: blocks_pdu_to_tagged_stream
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: blocks_socket_pdu_input
  id: blocks_socket_pdu
  parameters:
    host: ''
    mtu: mtu_size
    port: tunnel_input_port
    tcp_no_delay: 'False'
    type: UDP_SERVER
  states: {}
- name: blocks_socket_pdu_output
  id: blocks_socket_pdu
  parameters:
    host: localhost
    mtu: mtu_size
    port: tunnel_output_port
    tcp_no_delay: 'False'
    type: UDP_CLIENT
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: test_packet_len
    type: byte
  states: {state: disabled}
- name: blocks_tag_gate_0
  id: blocks_tag_gate
  parameters:
    propagate_tags: 'False'
    type: byte
  states: {state: disabled}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: packet_len
    type: byte
  states: {state: disabled}
- name: dst_id
  id: parameter
  parameters:
    label: destination ID aka PHY ID of remote
    type: intx
    value: '42'
  states: {}
- name: latency_pdu_time_stamper_input
  id: latency_pdu_time_stamper
  parameters:
    key_string: time
    name: Input FOO
  states: {}
- name: latency_pdu_time_stamper_output
  id: latency_pdu_time_stamper
  parameters:
    key_string: time
    name: outputfoo
  states: {}
- name: mtu_size
  id: parameter
  parameters:
    label: MTU size
    type: intx
    value: '68'
  states: {}
- name: src_id
  id: parameter
  parameters:
    label: source ID aka PHY ID of host
    type: intx
    value: '21'
  states: {}
- name: tacmac_mac_controller_inteface
  id: tacmac_mac_controller
  parameters:
    destination_id: dst_id
    mtu_size: mtu_size
    source_id: src_id
  states: {}
- name: tacmac_mac_controller_loopback
  id: tacmac_mac_controller
  parameters:
    destination_id: '21'
    mtu_size: mtu_size
    source_id: '42'
  states: {state: disabled}
- name: zeromq_pull_msg_source_0
  id: zeromq_pull_msg_source
  parameters:
    timeout: '100'
  states: {state: disabled}
- name: zeromq_pull_msg_source_0_0
  id: zeromq_pull_msg_source
  parameters:
    address: zmq_receive_address
    timeout: '100'
  states: {}
- name: zeromq_push_msg_sink_0
  id: zeromq_push_msg_sink
  parameters:
    address: zmq_target_address
    timeout: '100'
  states: {}
- name: zmq_remote
  id: parameter
  parameters:
    label: 0MQ remote IP
    type: str
    value: 127.0.0.1
  states: {}

connections:
- [blocks_pdu_set_0, pdus, zeromq_push_msg_sink_0, in]
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tag_gate_0, '0']
- [blocks_pdu_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_socket_pdu_input, pdus, latency_pdu_time_stamper_input, PDUin]
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tag_gate_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, tacmac_mac_controller_loopback, LLCin]
- [latency_pdu_time_stamper_input, PDUout, tacmac_mac_controller_inteface, LLCin]
- [latency_pdu_time_stamper_output, PDUout, blocks_message_debug_0, print_pdu]
- [latency_pdu_time_stamper_output, PDUout, blocks_socket_pdu_output, pdus]
- [tacmac_mac_controller_inteface, LLCout, latency_pdu_time_stamper_output, PDUin]
- [tacmac_mac_controller_inteface, PHYout, blocks_pdu_set_0, pdus]
- [tacmac_mac_controller_inteface, PHYout, tacmac_mac_controller_loopback, PHYin]
- [tacmac_mac_controller_loopback, LLCout, blocks_pdu_to_tagged_stream_0, pdus]
- [tacmac_mac_controller_loopback, PHYout, tacmac_mac_controller_inteface, PHYin]
- [zeromq_pull_msg_source_0_0, out, tacmac_mac_controller_inteface, PHYin]

metadata:
  file_format: 1
