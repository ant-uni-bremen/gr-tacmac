options:
  parameters:
    author: Johannes Demel
    category: '[GFDM]'
    generate_options: hb
    id: hier_gfdm_receiver
    output_language: python
    title: PHY Receiver
  states: {}

blocks:
- name: frame_len
  id: variable
  parameters:
    value: timeslots * subcarriers + 2 * cp_len + 2 * cs_len + 2 * subcarriers
  states: {}
- name: polar_info_bytes
  id: variable
  parameters:
    value: info_size // 8
  states: {}
- name: var_decoder
  id: variable_polarwrap_decoderwrap
  parameters:
    block_size: frame_size
    decoder_impl: mixed
    dim1: '1'
    dim2: '4'
    error_detection_type: '16'
    frozen_bit_positions: frozen_bit_positions
    list_size: list_size
    ndim: '0'
  states: {}
- name: activate_cfo_compensation
  id: parameter
  parameters:
    label: Activate CFO compensation
    type: intx
    value: '1'
  states: {}
- name: active_subcarriers
  id: parameter
  parameters:
    label: Active subcarriers
    type: intx
    value: '60'
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: length_tag_key
    packet_len: polar_info_bytes
    type: byte
  states: {}
- name: blocks_tagged_stream_to_pdu_0
  id: blocks_tagged_stream_to_pdu
  parameters:
    tag: rx_len
    type: byte
  states: {}
- name: cp_len
  id: parameter
  parameters:
    label: CP length
    type: intx
    value: '16'
  states: {}
- name: cs_len
  id: parameter
  parameters:
    label: CS length
    type: intx
    value: '8'
  states: {}
- name: fec_generic_decoder_0
  id: fec_generic_decoder
  parameters:
    alias: POLARdecoder
    decoder: var_decoder
    itype: float
    otype: byte
  states: {}
- name: frame_size
  id: parameter
  parameters:
    label: Frame size (bits)
    type: intx
    value: '936'
  states: {}
- name: frequency_domain_taps
  id: parameter
  parameters:
    label: Frequency domain taps
    value: list(range(60))
  states: {}
- name: frozen_bit_positions
  id: parameter
  parameters:
    label: Frozen Bit positions
    value: np.arange(768, dtype=int)
  states: {}
- name: gfdm_constellation
  id: parameter
  parameters:
    label: Constellation object
    value: digital.constellation_calcdist([-0.707-0.707j, -0.707+0.707j, 0.707+0.707j, 0.707-0.707j], [0, 1, 3, 2],4, 1).base()
  states: {}
- name: ic_iterations
  id: parameter
  parameters:
    label: IC iterations
    type: intx
    value: '2'
  states: {}
- name: import_0
  id: import
  parameters:
    imports: from gnuradio import digital
  states: {}
- name: import_numpy
  id: import
  parameters:
    imports: import numpy as np
  states: {}
- name: info_size
  id: parameter
  parameters:
    label: Info size (bits)
    type: intx
    value: 256 - 8
  states: {}
- name: interleaver_indices
  id: parameter
  parameters:
    label: Interleaver indices
    value: np.arange(936, dtype=int)
  states: {}
- name: list_size
  id: parameter
  parameters:
    label: List size
    type: intx
    value: '4'
  states: {}
- name: overlap
  id: parameter
  parameters:
    label: Overlap
    type: intx
    value: '2'
  states: {}
- name: pad_sink_0_0_0_0_0
  id: pad_sink
  parameters:
    label: pdus
    type: message
  states: {}
- name: pad_source_0
  id: pad_source
  parameters:
    label: in0
    type: complex
  states: {}
- name: pad_source_0_0
  id: pad_source
  parameters:
    label: in1
    type: complex
  states: {}
- name: phase_compensate
  id: parameter
  parameters:
    label: Do phase compensation
    value: 'True'
  states: {}
- name: preamble
  id: parameter
  parameters:
    label: Core preamble
    value: list(range(128))
  states: {}
- name: ramp_len
  id: parameter
  parameters:
    label: Ramp length
    type: intx
    value: '8'
  states: {}
- name: scorr_threshold_high
  id: parameter
  parameters:
    label: SC Higher Threshold
    type: eng_float
    value: '.98'
  states: {}
- name: scorr_threshold_low
  id: parameter
  parameters:
    label: SC Lower Threshold
    type: eng_float
    value: '0.93'
  states: {}
- name: subcarrier_map
  id: parameter
  parameters:
    label: Subcarrier map
    value: list(range(60))
  states: {}
- name: subcarriers
  id: parameter
  parameters:
    label: Subcarriers
    type: intx
    value: '64'
  states: {}
- name: symbolmapping_interleaver_0
  id: symbolmapping_interleaver
  parameters:
    interleaver_indices: interleaver_indices
    interleaver_mode: deinterleave
    is_packed: '1'
    type: float
  states: {}
- name: tacmac_lower_phy_receiver_0
  id: tacmac_lower_phy_receiver
  parameters:
    activate_cfo_compensation: 'True'
    activate_phase_compensation: 'True'
    active_subcarriers: '60'
    constellation: ''
    cp_len: '16'
    cs_len: '8'
    frequency_domain_taps: '[1.0 + 0.0j, ] * 30'
    ic_iterations: '1'
    nport: '2'
    overlap: '2'
    packet_length_key: '"packet_len"'
    preamble: '[1.0 + 0.0j, ] * 128'
    ramp_len: '8'
    scorr_threshold_high: '0.98'
    scorr_threshold_low: '0.93'
    subcarrier_map: list(range(60))
    subcarriers: '64'
    timeslots: '15'
    xcorr_threshold: '30.0'
  states: {}
- name: tag_key
  id: parameter
  parameters:
    label: Tag key
    type: str
    value: packet_len
  states: {}
- name: timeslots
  id: parameter
  parameters:
    label: Timeslots
    type: intx
    value: '15'
  states: {}
- name: xcorr_threshold
  id: parameter
  parameters:
    label: Xcorr detection threshold
    type: eng_float
    value: '30.'
  states: {}

connections:
- [blocks_stream_to_tagged_stream_0, '0', blocks_tagged_stream_to_pdu_0, '0']
- [blocks_tagged_stream_to_pdu_0, pdus, pad_sink_0_0_0_0_0, in]
- [fec_generic_decoder_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [pad_source_0, '0', tacmac_lower_phy_receiver_0, '0']
- [pad_source_0_0, '0', tacmac_lower_phy_receiver_0, '1']
- [symbolmapping_interleaver_0, '0', fec_generic_decoder_0, '0']
- [tacmac_lower_phy_receiver_0, '0', symbolmapping_interleaver_0, '0']

metadata:
  file_format: 1
